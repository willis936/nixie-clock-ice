File: hardware/KiCad/nixieAccurateClock/nixieAccurateClock.kicad_pcb (KiCad board)
At the start: 4 copper layers, 152.4 x 101.6 mm, 102 parts, among them J1 Conn_01x02_Pin, J10 Conn_01x02_Pin, J17 Conn_02x05_Odd_Even, J2 Conn_01x02_Pin, J3 Conn_01x02_Pin, J4 pico iCE (A), J5 pico iCE (B), J6 Conn_01x02_Pin, J7 Conn_01x02_Pin, J8 Conn_Coaxial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

Commit message: update to KiCAD 8
Parts:
- C9: value locked -> 0.1u
- turned C3 to -90 degrees
Connections:
- C3 pad 1: /GPS/VCC_{GPS} -> +3.3V
- C3 pad 2: +3.3V -> /GPS/VCC_{GPS}
