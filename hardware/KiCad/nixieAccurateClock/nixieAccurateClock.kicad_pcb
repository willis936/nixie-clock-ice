# Repository willis936/nixie-clock-ice (continued)

## KiCad design hardware/KiCad/nixieAccurateClock/nixieAccurateClock.kicad_pcb (continued)

Board: 4 copper layers, 152.4 x 101.6 mm, 102 parts (0 on the bottom side), 101 nets.

File hardware/BOM-nixieAccurateClock.xlsx (part):

Source: | KiCad\nixieAccurateClock\nixieAccurateClock.kicad_sch
Date: | 45345.906342592592
Tool: | Eeschema 7.0.9
Generator: | C:\Program Files\KiCad\7.0\bin\scripting\plugins/bom_csv_grouped_by_value.py
Component Count: | 80
Collated Components:
Item | Qty | Reference | Value | Model | DNP | Price | Sub-total | LibPart | Footprint | Datasheet | Digikey link | Mouser link
1 | 1 | BT1 | Battery_Cell | 3002 |  | 0.46 | 0.46 | Device:Battery_Cell | Battery:BatteryHolder_Keystone_3002_1x2032 | https://www.keyelco.com/userAssets/file/M65p9.pdf | https://www.digikey.com/en/products/detail/keystone-electron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 | https://www.mouser.com/ProductDetail/Keystone-Electronics/30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
2 | 7 | C1, C2, C3, C11, C13, C15, C17 | 0.1u | CL10B104KB8NNWC |  | 0.1 | 0.70000000000000007 | Device:C_Small | Capacitor_SMD:C_0603_1608Metric | https://mm.digikey.com/Volume0/opasdata/d220001/medias/docus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 | https://www.digikey.com/en/products/detail/samsung-electro-m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 | https://www.mouser.com/ProductDetail/Samsung-Electro-Mechani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
3 | 4 | C4, C5, C6, C7 | 1u | UUX2G010MNL1GS |  | 0.69 | 2.76 | Device:C_Polarized | Capacitor_SMD:CP_Elec_8x10 | https://www.nichicon.co.jp/english/series_items/catalog_pdf/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 | https://www.digikey.com/en/products/detail/nichicon/UUX2G010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 | https://www.mouser.com/ProductDetail/Nichicon/UUX2G010MNL1GS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
4 | 1 | C8 | 1u | CL10A105KA8NNNC |  | 0.1 | 0.1 | Device:C | Capacitor_SMD:C_0603_1608Metric | https://mm.digikey.com/Volume0/opasdata/d220001/medias/docus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 | https://www.digikey.com/en/products/detail/samsung-electro-m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 | https://www.mouser.com/ProductDetail/Samsung-Electro-Mechani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
5 | 5 | C9, C10, C12, C14, C16 | 0.1u | CL10B104KB8NNWC |  | 0.1 | 0.5 | :C_Small_1 | Capacitor_SMD:C_0603_1608Metric | https://mm.digikey.com/Volume0/opasdata/d220001/medias/docus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 | https://www.digikey.com/en/products/detail/samsung-electro-m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 | https://www.mouser.com/ProductDetail/Samsung-Electro-Mechani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
6 | 5 | D1, D2, D3, D5, D6 | SM4004 | SM4004 |  | 0.27 | 1.35 | Diode:SM4004 | Diode_SMD:D_MELF | http://cdn-reichelt.de/documents/datenblatt/A400/SMD1N400%23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 | https://www.digikey.com/en/products/detail/diotec-semiconduc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 | https://www.mouser.com/ProductDetail/Diotec-Semiconductor/SM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
7 | 1 | D4 | 1SMB5956B-13 |  |  | 0.46 | 0.46 | Device:D_Zener | Diode_SMD:D_SMB | https://www.diodes.com/assets/Datasheets/ds32125.pdf | https://www.digikey.com/en/products/detail/diodes-incorporat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 | https://www.mouser.com/ProductDetail/Diodes-Incorporated/1SM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
8 | 5 | J1, J2, J3, J9, J10 | Conn_01x02_Pin | TSM-102-01-L-SV |  | 0.42 | 2.1 | Connector:Conn_01x02_Pin | Connector_PinHeader_2.54mm:PinHeader_1x02_P2.54mm_Vertical_SMD_Pin1Left | https://suddendocs.samtec.com/catalog_english/tsm.pdf | https://www.digikey.com/en/products/detail/samtec-inc/TSM-10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 | https://www.mouser.com/ProductDetail/Samtec/TSM-102-01-L-SV?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
9 | 2 | J4, J5 | pico iCE (A) | SSM-120-L-DV-A |  | 6.65 | 13.3 | 00_lib:pico_iCE (A) | 00_lib:pico iCE (A) | https://suddendocs.samtec.com/catalog_english/ssm_sm.pdf | https://www.digikey.com/en/products/detail/samtec-inc/SSM-12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 | https://www.mouser.com/ProductDetail/Samtec/SSM-120-L-DV-A?q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
10 | 2 | J6, J7 | Conn_01x02_Pin | TSM-102-01-L-SV |  | 0.42 | 0.84 | :Conn_01x02_Pin_1 | Connector_PinHeader_2.54mm:PinHeader_1x02_P2.54mm_Vertical_SMD_Pin1Left | https://suddendocs.samtec.com/catalog_english/tsm.pdf | https://www.digikey.com/en/products/detail/samtec-inc/TSM-10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 | https://www.mouser.com/ProductDetail/Samtec/TSM-102-01-L-SV?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
11 | 1 | J8 | Conn_Coaxial | 132289 |  | 7.55 | 7.55 | Connector:Conn_Coaxial | 00_lib:SMA_Amphenol_132289_EdgeMount | https://www.mouser.com/datasheet/2/18/1/amphs06501_1-2259276.pdf | https://www.digikey.com/en/products/detail/amphenol-rf/13228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 | https://www.mouser.com/ProductDetail/Amphenol-RF/132289?qs=n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
12 | 7 | J11, J12, J13, J14, J15, J16, J17 | ~ | SSM-105-L-DV |  | 2.59 | 18.13 | :nixie_daughter_board_1 | 00_lib:IN-14 daughter board | http://suddendocs.samtec.com/catalog_english/ssm_sm.pdf | https://www.digikey.com/en/products/detail/samtec-inc/SSM-10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 | https://www.mouser.com/ProductDetail/Samtec/SSM-105-L-DV?qs=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
13 | 1 | L1 | 10u | SRR1280-100M |  | 1.02 | 1.02 | Device:L | 00_lib:IND_BOURNS_SRR1280 | https://www.bourns.com/docs/Product-Datasheets/SRR1280.pdf | https://www.digikey.com/en/products/detail/bourns-inc/SRR128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 | https://www.mouser.com/ProductDetail/Bourns/SRR1280-100M?qs=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
14 | 6 | Q1, Q2, Q3, Q4, Q5, Q6 | PZTA42 |  |  | 0.41 | 2.46 | Transistor_BJT:PZTA42 | Package_TO_SOT_SMD:SOT-223-3_TabPin2 | https://www.onsemi.com/pub/Collateral/PZTA42T1-D.PDF | https://www.digikey.com/en/products/detail/micro-commercial-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 | https://www.mouser.com/ProductDetail/Diotec-Semiconductor/PZ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
15 | 2 | R1, R2 | 1k | RC0603FR-071KL |  | 0.1 | 0.2 | Device:R | Resistor_SMD:R_0603_1608Metric | https://www.yageo.com/upload/media/product/app/datasheet/rch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 | https://www.digikey.com/en/products/detail/yageo/RC0603FR-07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 | https://www.mouser.com/ProductDetail/YAGEO/RC0603FR-071KL?qs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
16 | 1 | R3 | 10M | RMCF0603FT10M0 |  | 0.1 | 0.1 | Device:R | Resistor_SMD:R_0603_1608Metric | https://www.seielect.com/catalog/sei-rmcf_rmcp.pdf | https://www.digikey.com/en/products/detail/stackpole-electro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 | https://www.mouser.com/ProductDetail/SEI-Stackpole/RMCF0603F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
17 | 2 | R4, R11 | 100k | RC0603JR-07100KL |  | 0.1 | 0.2 | Device:R | Resistor_SMD:R_0603_1608Metric | https://www.yageo.com/upload/media/product/app/datasheet/rch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 | https://www.digikey.com/en/products/detail/yageo/RC0603JR-07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 | https://www.mouser.com/ProductDetail/YAGEO/RC0603JR-07100KL?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
18 | 4 | R5, R6, R7, R8 | 0.5 | CSRN2010FKR500 |  | 0.42 | 1.68 | Device:R | Resistor_SMD:R_2010_5025Metric | https://www.seielect.com/catalog/sei-csr_csrn.pdf | https://www.digikey.com/en/products/detail/stackpole-electro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 | https://www.mouser.com/ProductDetail/SEI-Stackpole/CSRN2010F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
19 | 2 | R9, R12 | 1M | RMCF0603FT1M00 |  | 0.1 | 0.2 | Device:R | Resistor_SMD:R_0603_1608Metric | https://www.seielect.com/catalog/sei-rmcf_rmcp.pdf | https://www.digikey.com/en/products/detail/stackpole-electro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 | https://www.mouser.com/ProductDetail/SEI-Stackpole/RMCF0603F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
20 | 1 | R10 | 10k | 352010KJT |  | 0.43 | 0.43 | Device:R | Resistor_SMD:R_2512_6332Metric | https://www.te.com/commerce/DocumentDelivery/DDEController?A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 | https://www.digikey.com/en/products/detail/te-connectivity-p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 | https://www.mouser.com/ProductDetail/TE-Connectivity-Holswor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
21 | 1 | R13 | 47k | RC0603FR-0747KL |  | 0.1 | 0.1 | Device:R | Resistor_SMD:R_0603_1608Metric | https://www.yageo.com/upload/media/product/products/datashee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 | https://www.digikey.com/en/products/detail/yageo/RC0603FR-07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 | https://www.mouser.com/ProductDetail/YAGEO/RC0603FR-0747KL?q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
22 | 1 | RV1 | 100k | 3269X-1-104GLF |  | 3.68 | 3.68 | Device:R_Potentiometer | Potentiometer_SMD:Potentiometer_Bourns_3269X_Horizontal | https://www.bourns.com/docs/Product-Datasheets/3269.pdf | https://www.digikey.com/en/products/detail/bourns-inc/3269X-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 | https://www.mouser.com/ProductDetail/Bourns/3269X-1-104GLF?q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
23 | 1 | SW1 | SW_DIP_x08 | 219-8MST |  | 0.95 | 0.95 | Switch:SW_DIP_x08 | Button_Switch_SMD:SW_DIP_SPSTx08_Slide_6.7x21.88mm_W8.61mm_P2.54mm_LowProfile | https://www.ctscorp.com/wp-content/uploads/219.pdf | https://www.digikey.com/en/products/detail/cts-electrocompon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 | https://www.mouser.com/ProductDetail/CTS-Electronic-Componen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
24 | 9 | TP1, TP2, TP3, TP4, TP5, TP6, TP7, TP8, TP9 | TestPoint | 5019 |  | 0.33 | 2.97 | Connector:TestPoint | 00_lib:TestPoint_Keystone_5019_Minature | https://www.mouser.com/datasheet/2/215/019-743690.pdf | https://www.digikey.com/en/products/detail/keystone-electron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 | https://www.mouser.com/ProductDetail/Keystone-Electronics/50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
25 | 1 | U1 | MCP23008-xSO |  |  | 1.37 | 1.37 | Interface_Expansion:MCP23008-xSO | Package_SO:SOIC-18W_7.5x11.6mm_P1.27mm | http://ww1.microchip.com/downloads/en/DeviceDoc/MCP23008-MCP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 | https://www.digikey.com/en/products/detail/microchip-technol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 | https://www.mouser.com/ProductDetail/Microchip-Technology/MC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

## KiCad design hardware/KiCad/nixieAccurateClock/IN-14-daughter/IN-14-daughter.kicad_pcb

Parts:
C1, C2: 0.1u; C_0603_1608Metric
FID1, FID2, FID3: Fiducial; Fiducial_0.5mm_Mask1.5mm
H1, H2: MountingHole_Pad; MountingHole_2.7mm_M2.5_Pad_Via
J1: Conn_02x05_Odd_Even; PinHeader_2x05_P2.54mm_Vertical_SMD
N1: IN-14; nixies-us-IN-14; Digikey link N/A; not fitted
R1: 27k; R_1206_3216Metric
U1: HV509K6-G; QFN-32-1EP_5x5mm_P0.5mm_EP3.3x3.3mm_ThermalVias

Connections:
+3.3V: C1.2, J1.6
+5V: C2.2, J1.2
/ANODE: J1.7, N1.A, R1.2
/CLK: J1.8, U1.19 (CLK)
/DIN: J1.4, U1.17 (DIN)
/DOUT: J1.1, U1.24 (DOUT)
/N_0: N1.0, U1.31 (HVOUT14)
/N_1: N1.1, U1.12 (HVOUT1)
/N_2: N1.2, U1.11 (HVOUT2)
/N_3: N1.3, U1.9 (HVOUT4)
/N_4: N1.4, U1.8 (HVOUT5)
/N_5: N1.5, U1.6 (HVOUT7)
/N_6: N1.6, U1.4 (HVOUT9)
/N_7: N1.7, U1.2 (HVOUT11)
/N_8: N1.8, U1.1 (HVOUT12)
/N_9: N1.9, U1.32 (HVOUT13)
/N_LHDP: N1.LHDP, U1.29 (HVOUT16)
/N_RHDP: N1.RHDP, U1.30 (HVOUT15)
/VBIAS: C2.1, U1.26 (VBIAS)
/VDD: C1.1, U1.20 (VDD)
/~LE: J1.3, U1.22 (~LE)
GND: H1.1, H2.1, J1.5, J1.10, U1.15 (GND), U1.21 (~POL), U1.33 (EPAD)
VPP: J1.9, R1.1, U1.14 (VPP)

Board: 4 copper layers, 19.0 x 36.4 mm, 11 parts (8 on the bottom side), 23 nets.

## KiCad design KiCad/nixieAccurateClock/nixieAccurateClock.kicad_pcb

Board: 4 copper layers, 152.4 x 101.6 mm, 113 parts (0 on the bottom side), 119 nets.

Parts:
BT1: Battery_Cell; BatteryHolder_Keystone_103_1x20mm
C1, C2, C3, C6, C14, C16, C17, C18, C19, C20: 0.1u; C_0603_1608Metric
C4, C7, C8, C9, C11, C13, C15: 1u; C_0603_1608Metric
C5, C10: 10u; CP_Elec_8x10
C12: 1n; C_0603_1608Metric
D1, D2, D3: SM4004; D_MELF
FID1, FID2, FID3: Fiducial; Fiducial_1mm_Mask3mm
H1, H2: MountingHole_Pad; MountingHole_2.7mm_M2.5_Pad_Via
J1, J2, J3, J4, J5, J7, J8, J9, J10: Conn_01x02_Pin; PinHeader_1x02_P2.54mm_Vertical
J6: Conn_Coaxial; SMA_Amphenol_132289_EdgeMount
J11: Conn_02x05_Odd_Even; PinSocket_2x05_P2.54mm_Horizontal
L1: 15u; IND_VLS6045EX-150M
L2: 820u; IND_MSS1583_COC
Q1, Q2, Q3, Q4, Q5: BSP88; SOT-223-3_TabPin2
R1, R2, R14, R15: 1k; R_0603_1608Metric
R3, R11: 62k; R_0603_1608Metric
R4: 27k; R_0603_1608Metric
R5, R17: 40m; R_0603_1608Metric
R6, R7, R8, R16, R18, R22, R26, R27, R28, R30: 100k; R_0603_1608Metric
R9: 470; R_0603_1608Metric
R10, R13: 4.7k; R_0603_1608Metric
R12, R29: 10M; R_0603_1608Metric
R19: 220k; R_0603_1608Metric
R20: 2.7M; R_0603_1608Metric
R21, R31, R32: 10k; R_0603_1608Metric
R23: 15k; R_0603_1608Metric
R24: 1M; R_0603_1608Metric
R25: 10k; R_2512_6332Metric
RV1: 100k; Potentiometer_Bourns_3266Z_Horizontal
SW1: SW_DIP_x08; SW_DIP_SPSTx08_Slide_6.7x21.88mm_W8.61mm_P2.54mm_LowProfile
TP1, TP2, TP3, TP4, TP5, TP6, TP7, TP8, TP9, TP10, TP11, TP12, TP13, TP14, TP15, TP16, TP17: TestPoint; TestPoint_Keystone_5019_Minature
U1: MCP23008-xSO; SOIC-18W_7.5x11.6mm_P1.27mm
U2: pico iCE
U3: LTR-329ALS-01; LTR-329ALS-01_LTO
U4: PX1125T
U5, U6: LM51561HPWPR; PWP0014H-IPC_C
U7, U8, U9, U10, U11, U12: IN-14 daughter board
U13: ADC0820BCWMX; SOIC-20W_7.5x12.8mm_P1.27mm
U14, U15: TXB0108PWR; TSSOP-20_4.4x6.5mm_P0.65mm

Connections:
+3.3V: C1.1, C2.1, C3.2, C17.1, C19.1, J4.2, J11.6, R1.2, R2.2, RV1.1, U1.3 (A2), U1.4 (A1), U1.5 (A0), U7.6 (+3.3V), U8.6 (+3.3V), U9.6 (+3.3V), U10.6 (+3.3V), U11.6 (+3.3V), U12.6 (+3.3V)
+3V3_STDBY: BT1.1 (+), J5.1, J7.1
+5V: C16.1, C18.1, C20.1, J3.2, J8.1, J11.2, L1.1, Q4.1 (G), U7.2 (+5V), U8.2 (+5V), U9.2 (+5V), U10.2 (+5V), U11.2 (+5V), U12.2 (+5V)
+20V: J9.2, L2.1, R11.2, U6.1 (BIAS)
/3.3V_STDBY_SRAM_{SENSE}: J5.2, U2.77 (+3V3_STDBY)
/3.3V_{SENSE}: J4.1, U2.5 (+3.3V), U2.6 (+3.3V), U2.55 (+3.3V), U2.56 (+3.3V), U2.73 (+3.3V), U2.74 (+3.3V), U2.75 (+3.3V)
/5V_{SENSE}: J3.1, U2.76 (VBUS)
/20V supply/5V_20V_{SENSE}: J8.2, R3.2, U5.1 (BIAS)
/20V supply/20V_{BOOST}: D1.2 (A), L1.2, Q1.2 (D), TP1.1
/20V supply/20V_{COMP-1}: C8.1, R9.2
/20V supply/20V_{COMP}: C7.1, R9.1, TP5.1, U5.8 (COMP)
/20V supply/20V_{CS}: Q1.3 (S), R5.1, U5.7 (CS)
/20V supply/20V_{FB}: R8.1, R10.2, TP4.1, U5.10 (FB)
/20V supply/20V_{GATE}: Q1.1 (G), TP3.1, U5.4 (GATE)
/20V supply/20V_{PGOOD}: R6.1, U5.13 (PGOOD)
/20V supply/20V_{RT}: R7.2, U5.12 (RT)
/20V supply/20V_{SENSE}: C5.1, D1.1 (K), J9.1, R8.2
/20V supply/20V_{SS}: C6.1, U5.11 (SS)
/20V supply/20V_{UVLO}: R3.1, R4.2, TP2.1, U5.14 (EN_UVLO_SYNC)
/20V supply/20V_{VCC}: C4.1, R6.2, U5.3 (VCC)
/24h_mode: SW1.6, U1.12 (GP2)
/DST_check: SW1.1, U1.17 (GP7)
/DST_force: SW1.2, U1.16 (GP6)
/GPS/3.3V_STDBY_GPS_{SENSE}: J7.2, U4.22 (V_BCKP)
/GPS/RF_IN: J6.1 (In), U4.11 (RF_IN)
/GPS/VCC_{GPS}: C3.1, U4.23 (VCC)
/HV bleed/HV_bleed_{drain}: Q3.2 (D), R25.2, TP11.1
/HV bleed/HV_bleed_{gate}: D3.1 (K), Q3.1 (G), Q4.2 (D), TP12.1
/HV bleed/HV_bleed_{pulldown}: D3.2 (A), R24.1
/HV bleed/HV_bleed_{source}: C15.1, Q3.3 (S), R26.1, TP13.1
/High voltage supply/HV_{BOOST}: D2.2 (A), L2.2, Q2.2 (D), TP7.1
/High voltage supply/HV_{COMP-1}: C13.1, R21.2
/High voltage supply/HV_{COMP}: C12.1, R21.1, TP10.1, U6.8 (COMP)
/High voltage supply/HV_{CS-1}: R14.2, R15.1
/High voltage supply/HV_{CS}: R14.1, U6.7 (CS)
/High voltage supply/HV_{FB}: C14.1, R20.1, R22.1, R23.2, TP9.1, U6.10 (FB)
/High voltage supply/HV_{GATE}: Q2.1 (G), TP8.1, U6.4 (GATE)
/High voltage supply/HV_{PGOOD}: R18.1, U6.13 (PGOOD)
/High voltage supply/HV_{RT}: R19.2, U6.12 (RT)
/High voltage supply/HV_{SOURCE}: Q2.3 (S), R15.2, R17.1
/High voltage supply/HV_{SS}: C11.2, U6.11 (SS)
/High voltage supply/HV_{UVLO}: R11.1, R13.1, U6.14 (EN_UVLO_SYNC)
/High voltage supply/HV_{VCC}: C9.1, R18.2, U6.3 (VCC)
/INT_{IO-expander}: U1.8 (INT), U2.68 (RP_20)
/LSD ADC/LSD_{ADC_5V_D0}: U13.2 (DB0), U14.20 (B1)
/LSD ADC/LSD_{ADC_5V_D1}: U13.3 (DB1), U14.18 (B2)
/LSD ADC/LSD_{ADC_5V_D2}: U13.4 (DB2), U14.17 (B3)
/LSD ADC/LSD_{ADC_5V_D3}: U13.5 (DB3), U14.16 (B4)
/LSD ADC/LSD_{ADC_5V_D4}: U13.14 (DB4), U15.17 (B3)
/LSD ADC/LSD_{ADC_5V_D5}: U13.15 (DB5), U15.16 (B4)
/LSD ADC/LSD_{ADC_5V_D6}: U13.16 (DB6), U15.15 (B5)
/LSD ADC/LSD_{ADC_5V_D7}: U13.17 (DB7), U15.14 (B6)
/LSD ADC/LSD_{ADC_5V_MODE}: U13.7 (MODE), U14.14 (B6)
/LSD ADC/LSD_{ADC_5V_~CS}: U13.13 (~CS), U15.18 (B2)
/LSD ADC/LSD_{ADC_5V_~INT}: U13.9 (~INT), U14.12 (B8)
/LSD ADC/LSD_{ADC_5V_~OFL}: U13.18 (~OFL), U15.13 (B7)
/LSD ADC/LSD_{ADC_5V_~RD}: U13.8 (~RD), U14.13 (B7)
/LSD ADC/LSD_{ADC_5V_~WR/RDY}: U13.6 (~WR/RDY), U14.15 (B5)
/LSD ADC/LSD_{SHUNT_SC_Emitter}: Q5.3 (S), R32.1, TP16.1
/LSD ADC/LSD_{SHUNT_div}: Q5.1 (G), R29.2, R30.1, TP14.1
/LSD ADC/OE_{lvl-shift-1}: R27.2, U14.10 (OE)
/LSD ADC/OE_{lvl-shift-2}: R28.2, U15.10 (OE)
/LSD ADC/VCC_{ADC}: C16.2, U13.20 (V_{CC})
/LSD ADC/VCC_{lvl-shift-A-1}: C17.2, U14.2 (VCCA)
/LSD ADC/VCC_{lvl-shift-A-2}: C19.2, U15.2 (VCCA)
/LSD ADC/VCC_{lvl-shift-B-1}: C18.2, U14.19 (VCCB)
/LSD ADC/VCC_{lvl-shift-B-2}: C20.2, U15.19 (VCCB)
/LSD ADC/V_{SHUNT}: Q5.2 (D), R31.2, TP15.1, U13.1 (V_{IN})
/Nixies/DAISY_{HV-1}: U7.1 (DOUT), U8.4 (DIN)
/Nixies/DAISY_{HV-2}: U8.1 (DOUT), U9.4 (DIN)
/Nixies/DAISY_{HV-3}: U9.1 (DOUT), U10.4 (DIN)
/Nixies/DAISY_{HV-4}: U10.1 (DOUT), U11.4 (DIN)
/Nixies/DAISY_{HV-5}: U11.1 (DOUT), U12.4 (DIN)
/Nixies/D_{IN-PRECISE}: J11.4, U12.1 (DOUT)
/RESERVED_1: SW1.7, U1.11 (GP1)
/RESERVED_2: SW1.8, U1.10 (GP0)
/VCC_{ALS}: C2.2, U3.1 (VDD)
/VCC_{IO-expander}: C1.2, U1.18 (VDD)
/anti-poison_force: SW1.5, U1.13 (GP3)
/anti-poison_routine: SW1.4, U1.14 (GP4)
/brightness_control: RV1.2, U2.61 (RP_29_ADC3)
/manual_brightness: SW1.3, U1.15 (GP5)
/~ICE_RST: J2.1, U2.2 (RP_27/~ICE_RST)
/~RESET_{IO-expander}: U1.6 (~RESET), U2.70 (RP_22)
/~USB_BOOT: J1.1, U2.40 (~USB_BOOT)
CLOCK_{HV}: J11.8, U2.34 (ICE_4), U7.8 (CLOCK), U8.8 (CLOCK), U9.8 (CLOCK), U10.8 (CLOCK), U11.8 (CLOCK), U12.8 (CLOCK)
CLOCK_{PRECISE}: J11.7, U2.47 (ICE_19/RP_3)
DATA_{HV}: U2.33 (ICE_3), U7.4 (DIN)
DATA_{PRECISE}: J11.1, U2.48 (ICE_18/RP_7)
GND: BT1.2 (-), C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.1, C12.2, C13.2, C14.2, C15.2, H1.1, H2.1, J1.2, J2.2, J6.2 (Ext), J11.5, Q4.3 (S), R4.1, R5.2, R7.1, R10.1, R13.2, R16.2, R17.2, R19.1, R23.1, R26.2, R27.1, R28.1, R32.2, RV1.3, SW1.9, SW1.10, SW1.11, SW1.12, SW1.13, SW1.14, SW1.15, SW1.16, TP6.1, TP17.1, U1.9 (VSS), U2.4 (GND), U2.7 (GND), U2.8 (GND), U2.25 (GND), U2.26 (GND), U2.38 (GND), U2.53 (GND), U2.54 (GND), U2.71 (GND), U2.72 (GND), U2.80 (GND), U3.2 (GND), U4.10 (GND), U4.12 (GND), U4.13 (GND), U4.24 (GND), U5.5 (PGND), U5.6 (AGND), U5.9 (DITHOFF), U5.15 (EP), U6.5 (PGND), U6.6 (AGND), U6.9 (DITHOFF), U6.15 (EP), U7.5 (GND), U7.10 (GND), U8.5 (GND), U8.10 (GND), U9.5 (GND), U9.10 (GND), U10.5 (GND), U10.10 (GND), U11.5 (GND), U11.10 (GND), U12.5 (GND)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
GPS_{1PPS2}: U2.27 (ICE_44_G6), U4.4 (1PPS2)
GPS_{1PPS}: U2.28 (ICE_45), U4.3 (1PPS)
GPS_{BOOT_SEL}: U2.69 (RP_18), U4.1 (BOOT_SEL)
GPS_{RSTN}: U2.65 (RP_19), U4.8 (RSTN)
GPS_{RXD}: U2.67 (RP_16), U4.21 (RXD)
GPS_{TXD}: U2.63 (RP_17), U4.20 (TXD)
HV_{CONTROL}: R22.2, U2.64 (RP_21)
HV_{MEASURE}: R12.2, R16.1, R31.1, U2.59 (RP_28_ADC2|PB), U13.12 (V_{REF}(+))
HV_{SENSE}: C10.1, D2.1 (K), J10.1, R20.2, R24.2, R25.1
I2C_{CLOCK}: R1.1, U1.1 (SCL), U2.46 (ICE_23/RP_5), U3.4 (SCL)
I2C_{DATA}: R2.1, U1.2 (SDA), U2.50 (ICE_26/RP_4), U3.3 (SDA)
LSD_{ADC_D0}: U2.29 (ICE_46), U14.5 (A4)
LSD_{ADC_D1}: U2.30 (ICE_47), U14.4 (A3)
LSD_{ADC_D2}: U2.16 (ICE_43), U14.3 (A2)
LSD_{ADC_D3}: U2.15 (ICE_42), U14.1 (A1)
LSD_{ADC_D4}: U2.13 (ICE_36), U15.4 (A3)
LSD_{ADC_D5}: U2.12 (ICE_34), U15.5 (A4)
LSD_{ADC_D6}: U2.11 (ICE_32), U15.6 (A5)
LSD_{ADC_D7}: U2.10 (ICE_31), U15.7 (A6)
LSD_{ADC_MODE}: U2.20 (ICE_6), U14.7 (A6)
LSD_{ADC_~CS}: U2.14 (ICE_38), U15.3 (A2)
LSD_{ADC_~INT}: U2.22 (ICE_9), U14.9 (A8)
LSD_{ADC_~OFL}: U2.9 (ICE_28), U15.8 (A7)
LSD_{ADC_~RD}: U2.19 (ICE_11), U14.8 (A7)
LSD_{ADC_~WR/RDY}: U2.31 (ICE_48), U14.6 (A5)
LSD_{SHUNT}: R29.1, U12.7 (ANODE)
PPS_{TRIMMED}: J11.3, U2.52 (ICE_20_G3/RP_6), U7.3 (~LATCH), U8.3 (~LATCH), U9.3 (~LATCH), U10.3 (~LATCH), U11.3 (~LATCH), U12.3 (~LATCH)
SENSE_{PRECISE}: J11.10, U2.32 (ICE_2)
VPP: J10.2, J11.9, R12.1, R30.2, U7.9 (VPP), U8.9 (VPP), U9.9 (VPP), U10.9 (VPP), U11.9 (VPP), U12.9 (VPP)

File BOM-nixie-v3.xlsx (part):

Source: | C:\Users\willi\Nextcloud\Documents\Projects\nixieclock\nixie-clock-ice\KiCad\ni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
Date: | 45304.804212962961
Tool: | Eeschema 7.0.9
Generator: | C:\Program Files\KiCad\7.0\bin\scripting\plugins/bom_csv_grouped_by_value.py
Component Count: | 109
Collated Components:
Item | Qty | Reference | Value | Model | DNP | Price | Sub-total | LibPart | Footprint | Datasheet
1 | 1 | BT1 | Battery_Cell | 103 |  | 1.5 | 1.5 | Device:Battery_Cell | Battery:BatteryHolder_Keystone_103_1x20mm | https://www.keyelco.com/userAssets/file/M65p3.pdf
2 | 6 | C1, C2, C3, C6, C14, C17 | 0.1u | CL10B104KB8NNWC |  | 0.1 | 0.60000000000000009 | Device:C_Small | Capacitor_SMD:C_0603_1608Metric | https://mm.digikey.com/Volume0/opasdata/d220001/medias/docus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
3 | 7 | C4, C7, C8, C9, C11, C13, C15 | 1u | CL10A105KA8NNNC |  | 0.1 | 0.70000000000000007 | Device:C | Capacitor_SMD:C_0603_1608Metric | https://mm.digikey.com/Volume0/opasdata/d220001/medias/docus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
4 | 2 | C5, C10 | 10u | UVC2G100MPD1TD |  | 1.03 | 2.06 | Device:C_Polarized | Capacitor_THT:CP_Radial_D10.0mm_P5.00mm | https://www.nichicon.co.jp/english/products/pdfs/e-uvc.pdf
5 | 1 | C12 | 1n | C0603C102K5RAC7867 |  | 0.1 | 0.1 | Device:C | Capacitor_SMD:C_0603_1608Metric | https://connect.kemet.com:7667/gateway/IntelliData-Component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
6 | 1 | C16 | 0.1u | CL10B104KB8NNWC |  | 0.1 | 4.96 | :C_Small_1 | Capacitor_SMD:C_0603_1608Metric | https://mm.digikey.com/Volume0/opasdata/d220001/medias/docus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
7 | 1 | C18 | 0.1u | CL10B104KB8NNWC |  | 0.1 | 0.1 | :C_Small_4 | Capacitor_SMD:C_0603_1608Metric | https://mm.digikey.com/Volume0/opasdata/d220001/medias/docus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
8 | 1 | C19 | 0.1u | CL10B104KB8NNWC |  | 0.1 | 0.1 | :C_Small_2 | Capacitor_SMD:C_0603_1608Metric | https://mm.digikey.com/Volume0/opasdata/d220001/medias/docus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
9 | 1 | C20 | 0.1u | CL10B104KB8NNWC |  | 0.1 | 0.1 | :C_Small_3 | Capacitor_SMD:C_0603_1608Metric | https://mm.digikey.com/Volume0/opasdata/d220001/medias/docus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
10 | 3 | D1, D2, D3 | SM4004 | SM4004 |  | 0.27 | 0.81 | Diode:SM4004 | Diode_SMD:D_MELF | http://cdn-reichelt.de/documents/datenblatt/A400/SMD1N400%23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
11 | 5 | J1, J2, J6, J7, J8 | Conn_01x02_Pin | PH1-02-UA |  | 0.1 | 0.5 | Connector:Conn_01x02_Pin | Connector_PinHeader_2.54mm:PinHeader_1x02_P2.54mm_Vertical | https://app.adam-tech.com/products/download/data_sheet/20160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
12 | 1 | J3 | Conn_01x02_Pin | PH1-02-UA |  | 0.1 | 0.1 | :Conn_01x02_Pin_1 | Connector_PinHeader_2.54mm:PinHeader_1x02_P2.54mm_Vertical | https://app.adam-tech.com/products/download/data_sheet/20160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
13 | 1 | J4 | Conn_01x02_Pin | PH1-02-UA |  | 0.1 | 0.1 | :Conn_01x02_Pin_2 | Connector_PinHeader_2.54mm:PinHeader_1x02_P2.54mm_Vertical | https://app.adam-tech.com/products/download/data_sheet/20160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
14 | 1 | J5 | Conn_Coaxial | 132289 |  | 7.55 | 7.55 | Connector:Conn_Coaxial | 00_lib:SMA_Amphenol_132289_EdgeMount | https://www.mouser.com/datasheet/2/18/1/amphs06501_1-2259276.pdf
15 | 1 | J9 | Conn_02x05_Odd_Even | SFH11-PBPC-D05-RA-BK |  | 0.81 | 0.81 | Connector_Generic:Conn_02x05_Odd_Even | Connector_PinSocket_2.54mm:PinSocket_2x05_P2.54mm_Horizontal | https://s3.amazonaws.com/catalogspreads-pdf/PAGE123%20.100%2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
16 | 1 | L1 | 15u | VLS6045EX-150M |  | 0.41 | 0.41 | Device:L | 00_lib:IND_VLS6045EX-150M | https://product.tdk.com/en/system/files?file=dam/doc/product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
17 | 1 | L2 | 820u | MSS1583-824K |  | 4.07 | 4.07 | Device:L | 00_lib:IND_MSS1583_COC | https://www.coilcraft.com/getmedia/fbfe8ea7-f5d8-4484-859e-2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
18 | 5 | Q1, Q2, Q3, Q4, Q5 | BSP88 | BSP88 |  | 0.6 | 3 | 00_lib:BSP88 | Package_TO_SOT_SMD:SOT-223-3_TabPin2 | https://www.infineon.com/dgdl/Infineon-BSP88-DS-v02_02-en.pd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
19 | 4 | R1, R2, R10, R13 | 4.7k | RC0603JR-074K7L |  | 0.1 | 0.4 | Device:R | Resistor_SMD:R_0603_1608Metric | https://www.yageo.com/upload/media/product/app/datasheet/rch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
20 | 2 | R3, R11 | 62k | RMCF0603FT62K0 |  | 0.1 | 0.2 | Device:R | Resistor_SMD:R_0603_1608Metric | https://www.seielect.com/catalog/sei-rmcf_rmcp.pdf
21 | 1 | R4 | 27k | RC0603FR-0727KL |  | 0.1 | 0.1 | Device:R | Resistor_SMD:R_0603_1608Metric | https://www.yageo.com/upload/media/product/app/datasheet/rch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
22 | 2 | R5, R17 | 40m | WSLP0603R0400FEB |  | 0.74 | 1.48 | Device:R | Resistor_SMD:R_0603_1608Metric | https://www.vishay.com/docs/30122/wslp.pdf
23 | 10 | R6, R7, R8, R16, R18, R22, R26, R27, R28, R30 | 100k | RC0603JR-07100KL |  | 0.1 | 1 | Device:R | Resistor_SMD:R_0603_1608Metric | https://www.yageo.com/upload/media/product/app/datasheet/rch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
24 | 1 | R9 | 470 | RC0603JR-07470RL |  | 0.1 | 0.1 | Device:R | Resistor_SMD:R_0603_1608Metric | https://www.yageo.com/upload/media/product/app/datasheet/rch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
25 | 2 | R12, R29 | 10M | RMCF0603FT10M0 |  | 0.1 | 0.2 | Device:R | Resistor_SMD:R_0603_1608Metric | https://www.seielect.com/catalog/sei-rmcf_rmcp.pdf
26 | 2 | R14, R15 | 1k | RC0603FR-071KL |  | 0.1 | 0.2 | Device:R | Resistor_SMD:R_0603_1608Metric | https://www.yageo.com/upload/media/product/app/datasheet/rch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
27 | 1 | R19 | 220k | RMCF0603FT220K |  | 0.1 | 0.1 | Device:R | Resistor_SMD:R_0603_1608Metric | https://www.seielect.com/catalog/sei-rmcf_rmcp.pdf
28 | 1 | R20 | 2.7M | RC0603JR-072M7L |  | 0.1 | 0.1 | Device:R | Resistor_SMD:R_0603_1608Metric | https://www.yageo.com/upload/media/product/app/datasheet/rch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
29 | 3 | R21, R31, R32 | 10k | RC0603FR-0710KL |  | 0.1 | 0.30000000000000004 | Device:R | Resistor_SMD:R_0603_1608Metric | https://www.yageo.com/upload/media/product/app/datasheet/rch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
30 | 1 | R23 | 15k | RC0603FR-071K5L |  | 0.1 | 0.1 | Device:R | Resistor_SMD:R_0603_1608Metric | https://www.yageo.com/upload/media/product/app/datasheet/rch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
31 | 1 | R24 | 1M | RMCF0603FT1M00 |  | 0.1 | 0.1 | Device:R | Resistor_SMD:R_0603_1608Metric | https://www.seielect.com/catalog/sei-rmcf_rmcp.pdf
32 | 1 | R25 | 10k | ROX5SSJ10K |  | 0.6 | 0.6 | Device:R | Resistor_THT:R_Axial_DIN0617_L17.0mm_D6.0mm_P20.32mm_Horizontal | https://www.te.com/usa-en/product-8-2176412-0.datasheet.pdf
33 | 1 | RV1 | 100k | 3266Z-1-104LF |  | 4.2 | 4.2 | Device:R_Potentiometer | Potentiometer_THT:Potentiometer_Bourns_3266Z_Horizontal | https://www.bourns.com/docs/Product-Datasheets/3266.pdf
34 | 1 | SW1 | SW_DIP_x08 | 1825057-7 |  | 1.75 | 1.75 | Switch:SW_DIP_x08 | Button_Switch_THT:SW_DIP_SPSTx08_Slide_6.7x21.88mm_W7.62mm_P2.54mm_LowProfile | https://www.te.com/commerce/DocumentDelivery/DDEController?A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
35 | 20 | TP1, TP2, TP3, TP4, TP5, TP6, TP7, TP8, TP9, TP10, TP11, TP12, TP13, TP14, TP15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 | TestPoint | 5001 |  | 0.38 | 7.6 | Connector:TestPoint | TestPoint:TestPoint_Loop_D2.54mm_Drill1.5mm_Beaded | https://www.keyelco.com/userAssets/file/M65p56.pdf
36 | 1 | U1 | MCP23008-xSO |  |  | 1.37 | 1.37 | Interface_Expansion:MCP23008-xSO | Package_SO:SOIC-18W_7.5x11.6mm_P1.27mm | http://ww1.microchip.com/downloads/en/DeviceDoc/MCP23008-MCP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
37 | 1 | U2 | pico iCE |  |  | 35 | 35 | 00_lib:pico_iCE | 00_lib:pico iCE | https://pico-ice.tinyvision.ai/
38 | 1 | U3 | LTR-329ALS-01 |  |  | 0.97 | 0.97 | 00_lib:LTR-329ALS-01 | 00_lib:LTR-329ALS-01_LTO | https://optoelectronics.liteon.com/upload/download/DS86-2014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
39 | 1 | U4 | PX1125T |  |  | 27.8 | 27.8 | 00_lib:PX1125T | 00_lib:PX1125T | https://navspark.mybigcommerce.com/content/PX1125T_DS.pdf
40 | 2 | U5, U6 | LM51561HPWPR | LM51561HPWPR |  | 2.1800000000000002 | 4.3600000000000003 | 00_lib:LM51561HPWPR | 00_lib:PWP0014H-IPC_C | http://www.ti.com/general/docs/suppproductinfo.tsp?distId=10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
41 | 6 | U7, U8, U9, U10, U11, U12 | ~ |  |  | 21.41 | 128.46 | 00_lib:nixie_daughter_board | 00_lib:IN-14 daughter board
42 | 1 | U13 | ADC0820BCWMX | ADC0820BCWMX/NOPB |  | 5.93 | 5.93 | 00_lib:ADC0820-N | Package_SO:SOIC-20W_7.5x12.8mm_P1.27mm | https://www.ti.com/lit/ds/symlink/adc0820-n.pdf
43 | 1 | U14 | TXB0108PWR | TXB0108PWR |  | 1.65 | 1.65 | 00_lib:TXB0108PWR | Package_SO:TSSOP-20_4.4x6.5mm_P0.65mm | http://www.ti.com/lit/ds/symlink/txb0108.pdf
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
## Code that names these connections

File software/UP5K/pico-ice-blinky/up5k.pcf:

set_io --warn-no-port led_blue 39
set_io --warn-no-port led_green 40
set_io --warn-no-port led_red 41
set_io --warn-no-port clk 35

set_io --warn-no-port lsd_adc_ofl 28
set_io --warn-no-port lsd_adc_d7 31
set_io --warn-no-port lsd_adc_d6 32
set_io --warn-no-port lsd_adc_d5 34
set_io --warn-no-port lsd_adc_d4 36
set_io --warn-no-port lsd_adc_cs 38
set_io --warn-no-port lsd_adc_d3 42
set_io --warn-no-port lsd_adc_d2 43
set_io --warn-no-port lsd_adc_rd 11
set_io --warn-no-port lsd_adc_mode 6
set_io --warn-no-port lsd_adc_int 9

set_io --warn-no-port gps_pps2 44
set_io --warn-no-port gps_pps1 45
set_io --warn-no-port lsd_adc_d0 46
set_io --warn-no-port lsd_adc_d1 47
set_io --warn-no-port lsd_adc_wr_rdy 48
set_io --warn-no-port sense_precise 2
set_io --warn-no-port data_hv 3
set_io --warn-no-port clock_hv 4

set_io --warn-no-port i2c_clock 23
set_io --warn-no-port clock_precise 19
set_io --warn-no-port data_precise 18
set_io --warn-no-port i2c_data 26
set_io --warn-no-port pps_trimmed 20

File software/RP2040/main.c:

/*
 * MIT License
 *
 * Copyright (c) 2023 tinyVision.ai
 *
 * Permission is hereby granted, free of charge, to any person obtaining a copy
 * of this software and associated documentation files (the "Software"), to deal
 * in the Software without restriction, including without limitation the rights
 * to use, copy, modify, merge, publish, distribute, sublicense, and/or sell
 * copies of the Software, and to permit persons to whom the Software is
 * furnished to do so, subject to the following conditions:
 *
 * The above copyright notice and this permission notice shall be included in all
 * copies or substantial portions of the Software.
 *
 * THE SOFTWARE IS PROVIDED "AS IS", WITHOUT WARRANTY OF ANY KIND, EXPRESS OR
 * IMPLIED, INCLUDING BUT NOT LIMITED TO THE WARRANTIES OF MERCHANTABILITY,
 * FITNESS FOR A PARTICULAR PURPOSE AND NONINFRINGEMENT. IN NO EVENT SHALL THE
 * AUTHORS OR COPYRIGHT HOLDERS BE LIABLE FOR ANY CLAIM, DAMAGES OR OTHER
 * LIABILITY, WHETHER IN AN ACTION OF CONTRACT, TORT OR OTHERWISE, ARISING FROM,
 * OUT OF OR IN CONNECTION WITH THE SOFTWARE OR THE USE OR OTHER DEALINGS IN THE
 * SOFTWARE.
 */

// pico-sdk
#include "pico/stdio.h"
#include "hardware/irq.h"
#include "hardware/gpio.h"
#include "hardware/uart.h"
#include "hardware/i2c.h"
#include "pico/stdlib.h"
#include "boards/pico_ice.h"

// pico-ice-sdk
#include "ice_usb.h"
#include "ice_fpga.h"
#include "ice_led.h"

#define UART_TX_PIN 0
#define UART_RX_PIN 1

#define I2C i2c0
#define I2C_SDA_PIN 4
#define I2C_SCL_PIN 5
#define UART_GPS_RSTN_PIN 19
#define UART_GPS_TX_PIN 20
#define UART_GPS_RX_PIN 21
#define HV_CONTROL_PIN 17
#define HV_MEASURE_PIN 28
#define BRIGHTNESS_CONTROL_PIN 29
#define INT_IO_EXPAND_PIN 16
#define RESET_IO_EXPAND_PIN 22

#define DOC_FORWARD_SPI \
"https://pico-ice.tinyvision.ai/group__ice__usb.html#autotoc_md2"

#define DOC_DEFAULT_FIRMWARE \
"https://github.com/tinyvision-ai-inc/pico-ice/tree/main/Firmware/pico-ice-default"

// for repl_ungetchar() to take back the last character from repl_getchar():
int repl_last_char;
bool repl_last_held;

static int repl_getchar(void)
{
    int c;

    if (repl_last_held) {
        repl_last_held = false;
        return repl_last_char;
    }

    // busy-wait with a slow delay: this is for interactive I/O, no need to be fast
    while ((c = getchar_timeout_us(10000)) == PICO_ERROR_TIMEOUT) {
        // call tud_task() since we are blocking
        tud_task();
    }

    if (c == '\r' || c == '\n') {
        printf("\r\n");
    } else {
        putchar(c);
    }
    return c;
}

static void repl_ungetchar(int c)
{
    assert(!repl_last_held);
    repl_last_char = c;
    repl_last_held = true;
}

static inline bool repl_parse_error(char *msg, char c)
{
    // reset whatever was being input
    repl_last_held = false;

    printf("\nerror: expected %s got '%c'\n", msg, c);
    return false;
}

static bool repl_parse_newline(void)
{
    int c;

    switch (c = repl_getchar()) {
    case '\r':
    case '\n':
    case EOF:
        return true;
    default:
        repl_ungetchar(c);
        return repl_parse_error("newline", c);
    }
}

static void repl_command_version(void)
{
    if (!repl_parse_newline()) {
        return;
    }
    printf("pico-ice-sdk %s\r\n", VERSION);
}

int main(void) {
    // Enable USB-CDC #0 (serial console)
    stdio_init_all();

    // configure pins

    // RP2040 I2C
    i2c_init(i2c_default, 400 * 1000);
    gpio_set_function(I2C_SDA_PIN, GPIO_FUNC_I2C);
    gpio_set_function(I2C_SCL_PIN, GPIO_FUNC_I2C);
    gpio_pull_up(I2C_SDA_PIN);
    gpio_pull_up(I2C_SCL_PIN);

    // GPS UART
    uart_init(uart1, 115200);
    gpio_set_function(UART_GPS_TX_PIN, GPIO_FUNC_UART);
    gpio_set_function(UART_GPS_RX_PIN, GPIO_FUNC_UART);

    // ADCs
    adc_init();
    adc_gpio_init(HV_MEASURE_PIN);
    adc_gpio_init(BRIGHTNESS_CONTROL_PIN);

    // PWM output
    gpio_set_function(HV_CONTROL_PIN, GPIO_FUNC_PWM);

    // General Purpose Input/Output
    gpio_init(UART_GPS_RSTN_PIN);
    gpio_set_dir(UART_GPS_RSTN_PIN, GPIO_OUT);
    gpio_init(INT_IO_EXPAND_PIN);
    gpio_set_dir(INT_IO_EXPAND_PIN, GPIO_IN);
    gpio_init(RESET_IO_EXPAND_PIN);
    gpio_set_dir(RESET_IO_EXPAND_PIN, GPIO_OUT);

    // Enable the physical UART
    uart_init(uart0, 115200);
    gpio_set_function(UART_TX_PIN, GPIO_FUNC_UART);
    gpio_set_function(UART_RX_PIN, GPIO_FUNC_UART);

    // Configure the piping as configured in <tusb_config.h>
    ice_usb_init();

    // Let the FPGA start
    ice_fpga_init(12);
    ice_fpga_start();

    // Configure USB as defined in tusb_config.h
    ice_usb_init();

    // Prevent the LEDs from glowing slightly
    ice_led_init();

    while (true) {
        tud_task();

        printf("\x1b[1mpico-ice>\x1b[m ");

        switch (repl_getchar()) {
        case 'v':
            repl_command_version();
            break;
        default:
            printf("\r\n");
            printf("pico-ice default firmware\r\n", VERSION);
            printf("   %s\r\n", DOC_DEFAULT_FIRMWARE);
            printf("\r\n");
            printf("Serial port #0 - this shell, with commands:\r\n");
            printf("  v - print pico-ice-sdk version\r\n");
            printf("\r\n");
            printf("Serial port #1 - forwarding to UART\r\n");
            printf("  UART TX on RP0 = ICE27\r\n");
            printf("  UART RX on RP1 = ICE25\r\n");
            printf("\r\n");
            printf("Serial port #2 - forwarding to SPI:\r\n");
            printf("  %s\r\n", DOC_FORWARD_SPI);
            printf("\r\n");
            break;
        }

        printf("hello world\r\n");
    }
    return 0;
}
