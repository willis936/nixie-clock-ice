# Repository willis936/nixie-clock-ice

File README.md:

# nixie-clock-ice

 Hardware and software source for a GPS nixie tube clock with delay correction.

Uses a PICO-iCE v3 FPGA + MCU module.

 - Raspberry Pi RP2040 processor
 - Lattice UltraPlus ICE40UP5K FPGA with 5.3k LUTs, 1Mb SPRAM, 120Kb DPRAM, 8 Multipliers

# Building

## Cloning

Clone with git CLI of the native OS (Windows if running WSL).
This avoids checkout conflicts.
Github desktop recursively inits submodules, which breaks on Windows due to path length limitations.

```
git clone https://github.com/willis936/nixie-clock-ice.git
```

Once cloned cd to `software/lib` and run these commands to initialize the submodules:

```
git -C pico-ice-sdk submodule update --init
git -C pico-sdk submodule update --init lib/tinyusb
```

Run these commands until the output stops changing.  Running them once is likely not sufficient.

See the "Using the SDK" section of the pico iCE "Getting Started" page.

https://pico-ice.tinyvision.ai/md_getting_started.html

## MCU

Follow the pico ice Getting Started section.

Using Ubuntu WSL the apt version of cmake is currently not high enough.

Install an appropriate version like this:

https://www.linuxcapable.com/how-to-install-cmake-on-ubuntu-linux/

```
sudo apt update && sudo apt install build-essential checkinstall zlib1g-dev libssl-dev g++ gdb make ninja-build rsync zip gcc-arm-none-eabi
cd /usr/local/src
sudo wget https://github.com/Kitware/CMake/archive/refs/tags/v3.28.1.tar.gz
sudo tar -zxvf v3.28.1.tar.gz
sudo rm v3.28.1.tar.gz
cd CMake-3.28.1
sudo ./bootstrap
sudo make
sudo make install
```

For MacOS with homebrew installed:
```
brew install cmake gcc-arm-embedded zlib gdb make rsync zip
```

## FPGA

Make sure python 3.7+ is installed on WSL.

You may need to install pyenv, remove prior pip installations, and re-bootstrap.

https://gist.github.com/monkut/35c2ef098b871144b49f3f9979032cee

https://pip.pypa.io/en/stable/installation/

Install apio and oss CAD suite.

You may need to restart WSL in between the pip installation of the package and the package installation (last two commands).

```
sudo apt update && sudo apt install python3-pip yosys
pip install -U apio
apio install -a
```

For MacOS:
```
brew install yosys
pip3 install -U apio
```

Test project using the APIO guide here:

https://pico-ice.tinyvision.ai/md_programming_the_fpga.html

Use UF2 on WSL to convert the bin to UF2 then copy over CURRENT.UF2 on mounted USB drive pico ice.

https://github.com/tinyvision-ai-inc/uf2-utils/

```
cd /usr/local/src
sudo git clone https://github.com/tinyvision-ai-inc/uf2-utils.git
cd uf2-utils && sudo make install
```

# Enclosure development

If you want to modify the FreeCAD FCStd files you should configure zippey (located in `software/lib`) with these commands from git bash (Windows) or shell (linux) with the repo as pwd:

```
git config filter.zippey.smudge "$PWD/software/lib/zippey.py d"
git config filter.zippey.clean "$PWD/software/lib/zippey.py e"
```

Note that you need python 3 installed and added to path as `python` for the .FCStd files to properly compress on clone.

The enclosure was developed in FreeCAD 0.21.2 + Assembly3.  The Assembly3 plugin is needed to load the .FCStd file and modify the enclosure.

The enclosure starting point was generated by Protocase's template generator.

# Requirements

1. Display the time with 1 microsecond accuracy.
2. Display the time with 1 second precision.
3. Use nixie tubes to display the time.
4. Do not require or allow the user to manually set the time.
5. Display the time within 30 seconds of power on.
6. Use a single power entry.
7. Use a single radio receiver to establish local timebase.
8. Have a user-selectable mode for Daylight Savings Time (DST) checking.
9. Use longitude to estimate DST date range.
10. Have a user-selectable mode to force DST offset on (off when both this and DST check mode are off).
11. Use longitude to estimate timezone.
12. Have a user-selectable timezone offset.
13. Be able to use software to control nixie tube brightness.
14. Use an ambient light detector to automatically adjust nixie tube brightness.
15. Have a user-selectable manual brightness mode.
16. Use a potentiometer to set the brightness in manual brightness mode.
17. Run a nixie tube anti-poisoning routine once a day (cycle through all digits at high brightness for a minute).
18. Have a user-selectable mode to enable daily anti-poisoning routine
19. Have a user-selectable mode to force anti-poisoning routine on indefinitely.
20. Have a user-selectable 12-hour / 24-hour display mode.
21. Use a nixie tube decimal point to indicate AM/PM in 12-hour display mode.
22. Use a nixie tube decimal point to indicate that the radio receiver is locked.

## KiCad design hardware/KiCad/nixieAccurateClock/nixieAccurateClock.kicad_pcb

Parts:
FID1, FID2, FID3: Fiducial; Fiducial_1mm_Mask3mm
H1, H2, H3, H4, H5, H6, H7, H8, H9, H10, H11, H12, H13, H14, H15, H16, H17, H18: MountingHole_Pad; MountingHole_2.7mm_M2.5_Pad_Via

Connections:
GND: H1.1, H2.1, H3.1, H4.1, H5.1, H6.1, H7.1, H8.1, H9.1, H10.1, H11.1, H12.1, H13.1, H14.1, H15.1, H16.1, H17.1, H18.1; also elsewhere on the board

Parts:
J11, J12, J13, J14, J15, J16: IN-14 daughter board
J17: Conn_02x05_Odd_Even; M207920542R

Connections:
+3.3V: J11.6 (+3.3V), J12.6 (+3.3V), J13.6 (+3.3V), J14.6 (+3.3V), J15.6 (+3.3V), J16.6 (+3.3V), J17.6; also elsewhere on the board
+5V: J11.2 (+5V), J12.2 (+5V), J13.2 (+5V), J14.2 (+5V), J15.2 (+5V), J16.2 (+5V), J17.2; also elsewhere on the board
/LSD ADC/LSD_{SHUNT}: J16.7 (ANODE); also elsewhere on the board
/Nixies/CLOCK_{HV}: J11.8 (CLOCK), J12.8 (CLOCK), J13.8 (CLOCK), J14.8 (CLOCK), J15.8 (CLOCK), J16.8 (CLOCK), J17.8; also elsewhere on the board
/Nixies/CLOCK_{PRECISE}: J17.7; also elsewhere on the board
/Nixies/DAISY_{HV-1}: J11.1 (DOUT), J12.4 (DIN)
/Nixies/DAISY_{HV-2}: J12.1 (DOUT), J13.4 (DIN)
/Nixies/DAISY_{HV-3}: J13.1 (DOUT), J14.4 (DIN)
/Nixies/DAISY_{HV-4}: J14.1 (DOUT), J15.4 (DIN)
/Nixies/DAISY_{HV-5}: J15.1 (DOUT), J16.4 (DIN)
/Nixies/DATA_{HV}: J11.4 (DIN); also elsewhere on the board
/Nixies/DATA_{PRECISE}: J17.1; also elsewhere on the board
/Nixies/D_{IN-PRECISE}: J16.1 (DOUT), J17.4
/Nixies/PPS_{TRIMMED}: J11.3 (~LATCH), J12.3 (~LATCH), J13.3 (~LATCH), J14.3 (~LATCH), J15.3 (~LATCH), J16.3 (~LATCH), J17.3; also elsewhere on the board
/Nixies/SENSE_{PRECISE}: J17.10; also elsewhere on the board
GND: J11.5 (GND), J11.10 (GND), J12.5 (GND), J12.10 (GND), J13.5 (GND), J13.10 (GND), J14.5 (GND), J14.10 (GND), J15.5 (GND), J15.10 (GND), J16.5 (GND), J16.10 (GND), J17.5; also elsewhere on the board
VPP: J11.9 (VPP), J12.9 (VPP), J13.9 (VPP), J14.9 (VPP), J15.9 (VPP), J16.9 (VPP), J17.9; also elsewhere on the board

Notes on the sheet:
Extension for optional sub-second precision display. Pins 5 and 10 should both be connected to ground on the far side, which is used to sense when the board is connected. Precise clock and data lines for 1 ms and 0.1 ms digits.

Parts:
C8: 1u; C_0603_1608Metric
D6: SM4004; D_MELF
Q5, Q6: PZTA42; SOT-223-3_TabPin2
R9: 1M; R_0603_1608Metric
R10: 10k; R_2512_6332Metric
R11: 100k; R_0603_1608Metric
TP5, TP6, TP7: TestPoint; TestPoint_Keystone_5019_Minature

Connections:
+5V: Q6.1 (B); also elsewhere on the board
/HV bleed/HV_bleed_{drain}: Q5.2 (C), R10.2, TP5.1
/HV bleed/HV_bleed_{gate}: D6.1 (K), Q5.1 (B), Q6.2 (C), TP6.1
/HV bleed/HV_bleed_{pulldown}: D6.2 (A), R9.1
/HV bleed/HV_bleed_{source}: C8.1, Q5.3 (E), R11.1, TP7.1
/HV bleed/HV_{SENSE}: R9.2, R10.1; also elsewhere on the board
GND: C8.2, Q6.3 (E), R11.2; also elsewhere on the board

Notes on the sheet:
Drain HV capacitor in 300 ms. < 220 uA quiescent current. See ../../LTSpice/HV_Bleed.asc for simulation.

Parts:
C9, C10, C11, C12, C13, C14, C15, C16, C17: 0.1u; C_0603_1608Metric
R12: 1M; R_0603_1608Metric
R13: 47k; R_0603_1608Metric
TP8, TP9: TestPoint; TestPoint_Keystone_5019_Minature
U4, U5, U7, U8: TSSOP-14_4.4x5mm_P0.65mm
U6: ADC0820BCWMX; SOIC-20W_7.5x12.8mm_P1.27mm

Connections:
+3.3V: C11.1, C13.1, C15.1, C16.1, U4.8 (OE), U5.8 (OE), U7.8 (OE), U8.8 (OE); also elsewhere on the board
+5V: C9.1, C10.1, C12.1, C14.1, C17.1; also elsewhere on the board
/High voltage supply/MEASURE_{HV}: U6.12 (V_{REF}(+)); also elsewhere on the board
/LSD ADC/LSD_{ADC_5V_D0}: U4.5 (A4), U6.2 (DB0)
/LSD ADC/LSD_{ADC_5V_D1}: U4.4 (A3), U6.3 (DB1)
/LSD ADC/LSD_{ADC_5V_D2}: U4.3 (A2), U6.4 (DB2)
/LSD ADC/LSD_{ADC_5V_D3}: U4.2 (A1), U6.5 (DB3)
/LSD ADC/LSD_{ADC_5V_D4}: U5.5 (A4), U6.14 (DB4)
/LSD ADC/LSD_{ADC_5V_D5}: U5.4 (A3), U6.15 (DB5)
/LSD ADC/LSD_{ADC_5V_D6}: U5.3 (A2), U6.16 (DB6)
/LSD ADC/LSD_{ADC_5V_D7}: U5.2 (A1), U6.17 (DB7)
/LSD ADC/LSD_{ADC_5V_MODE}: U6.7 (MODE), U8.12 (B2Y)
/LSD ADC/LSD_{ADC_5V_~CS}: U6.13 (~CS), U8.10 (B4Y)
/LSD ADC/LSD_{ADC_5V_~INT}: U6.9 (~INT), U7.5 (A4)
/LSD ADC/LSD_{ADC_5V_~OFL}: U6.18 (~OFL), U7.4 (A3)
/LSD ADC/LSD_{ADC_5V_~RD}: U6.8 (~RD), U8.11 (B3Y)
/LSD ADC/LSD_{ADC_5V_~WR/RDY}: U6.6 (~WR/RDY), U8.13 (B1Y)
/LSD ADC/LSD_{ADC_D0}: U4.10 (B4Y); also elsewhere on the board
/LSD ADC/LSD_{ADC_D1}: U4.11 (B3Y); also elsewhere on the board
/LSD ADC/LSD_{ADC_D2}: U4.12 (B2Y); also elsewhere on the board
/LSD ADC/LSD_{ADC_D3}: U4.13 (B1Y); also elsewhere on the board
/LSD ADC/LSD_{ADC_D4}: U5.10 (B4Y); also elsewhere on the board
/LSD ADC/LSD_{ADC_D5}: U5.11 (B3Y); also elsewhere on the board
/LSD ADC/LSD_{ADC_D6}: U5.12 (B2Y); also elsewhere on the board
/LSD ADC/LSD_{ADC_D7}: U5.13 (B1Y); also elsewhere on the board
/LSD ADC/LSD_{ADC_MODE}: U8.3 (A2); also elsewhere on the board
/LSD ADC/LSD_{ADC_~CS}: U8.5 (A4); also elsewhere on the board
/LSD ADC/LSD_{ADC_~INT}: U7.10 (B4Y); also elsewhere on the board
/LSD ADC/LSD_{ADC_~OFL}: U7.11 (B3Y); also elsewhere on the board
/LSD ADC/LSD_{ADC_~RD}: U8.4 (A3); also elsewhere on the board
/LSD ADC/LSD_{ADC_~WR/RDY}: U8.2 (A1); also elsewhere on the board
/LSD ADC/LSD_{SHUNT}: R12.2; also elsewhere on the board
/LSD ADC/VCC_{ADC}: C9.2, U6.20 (V_{CC})
/LSD ADC/VCC_{lvl-shift-A-1}: C10.2, U4.1 (V_{CCA})
/LSD ADC/VCC_{lvl-shift-A-2}: C12.2, U5.1 (V_{CCA})
/LSD ADC/VCC_{lvl-shift-A-3}: C14.2, U7.1 (V_{CCA}), U7.2 (A1), U7.3 (A2)
/LSD ADC/VCC_{lvl-shift-A-4}: C16.2, U8.1 (V_{CCA})
/LSD ADC/VCC_{lvl-shift-B-1}: C11.2, U4.14 (V_{CCB})
/LSD ADC/VCC_{lvl-shift-B-2}: C13.2, U5.14 (V_{CCB})
/LSD ADC/VCC_{lvl-shift-B-3}: C15.2, U7.14 (V_{CCB})
/LSD ADC/VCC_{lvl-shift-B-4}: C17.2, U8.14 (V_{CCB})
/LSD ADC/V_{SHUNT}: R12.1, R13.2, TP8.1, U6.1 (V_{IN})
GND: R13.1, TP9.1, U4.7 (GND), U5.7 (GND), U6.10 (GND), U6.11 (V_{REF}(-)), U7.7 (GND), U8.7 (GND); also elsewhere on the board

Notes on the sheet:
Use HV_{MEASURE} signal as reference to have range track brightness.
LTSpice simulation demonstrates that if the Nixie tube is a 145 V drop then the ADC input should be ~0.5 FS range. Fluctuations in Nixie tube behavior should be well captured. Run the ADC at a fast rate and implement a high-pass filter with a threshold schmitt trigger to capture transition edge. Fi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

Parts:
BT1: Battery_Cell; BatteryHolder_Keystone_3002_1x2032
C3: 0.1u; C_0603_1608Metric
J8: Conn_Coaxial; SMA_Amphenol_132289_EdgeMount
J9: Conn_01x02_Pin; PinHeader_1x02_P2.54mm_Vertical_SMD_Pin1Right
U3: PX1125T; Digikey link N/A

Connections:
+3.3V: C3.1; also elsewhere on the board
+3.3V_STDBY: BT1.1 (+), J9.1; also elsewhere on the board
/GPS/+3.3V_STDBY_GPS_{SENSE}: J9.2, U3.22 (V_BCKP)
/GPS/GPS_{1PPS2}: U3.4 (1PPS2); also elsewhere on the board
/GPS/GPS_{1PPS}: U3.3 (1PPS); also elsewhere on the board
/GPS/GPS_{BOOT_SEL}: U3.1 (BOOT_SEL); also elsewhere on the board
/GPS/GPS_{RSTN}: U3.8 (RSTN); also elsewhere on the board
/GPS/GPS_{RXD}: U3.21 (RXD); also elsewhere on the board
/GPS/GPS_{TXD}: U3.20 (TXD); also elsewhere on the board
/GPS/RF_IN: J8.1 (In), U3.11 (RF_IN)
/GPS/VCC_{GPS}: C3.2, U3.23 (VCC)
GND: BT1.2 (-), J8.2 (Ext), U3.10 (GND), U3.12 (GND), U3.13 (GND), U3.24 (GND); also elsewhere on the board

Parts:
C1, C2: 0.1u; C_0603_1608Metric
RV1: 100k; Potentiometer_Bourns_3269X_Horizontal
SW1: SW_DIP_x08; SW_DIP_SPSTx08_Slide_6.7x21.88mm_W8.61mm_P2.54mm_LowProfile
U1: MCP23008-xSO; SOIC-18W_7.5x11.6mm_P1.27mm
U2: LTR-329ALS-01; LTR-329ALS-01_LTO

Connections:
+3.3V: C1.1, C2.1, RV1.1, U1.3 (A2), U1.4 (A1), U1.5 (A0); also elsewhere on the board
/Peripherals/24h_mode: SW1.6, U1.12 (GP2)
/Peripherals/DST_check: SW1.1, U1.17 (GP7)
/Peripherals/DST_force: SW1.2, U1.16 (GP6)
/Peripherals/I2C_{CLOCK}: U1.1 (SCL), U2.4 (SCL); also elsewhere on the board
/Peripherals/I2C_{DATA}: U1.2 (SDA), U2.3 (SDA); also elsewhere on the board
/Peripherals/INT_{IO-expander}: U1.8 (INT); also elsewhere on the board
/Peripherals/RESERVED_1: SW1.7, U1.11 (GP1)
/Peripherals/RESERVED_2: SW1.8, U1.10 (GP0)
/Peripherals/VCC_{ALS}: C2.2, U2.1 (VDD)
/Peripherals/VCC_{IO-expander}: C1.2, U1.18 (VDD)
/Peripherals/anti-poison_force: SW1.5, U1.13 (GP3)
/Peripherals/anti-poison_routine: SW1.4, U1.14 (GP4)
/Peripherals/brightness_control: RV1.2; also elsewhere on the board
/Peripherals/manual_brightness: SW1.3, U1.15 (GP5)
/Peripherals/~RESET_{IO-expander}: U1.6 (~RESET); also elsewhere on the board
GND: RV1.3, SW1.9, SW1.10, SW1.11, SW1.12, SW1.13, SW1.14, SW1.15, SW1.16, U1.9 (VSS), U2.2 (GND); also elsewhere on the board

Notes on the sheet:
Ambient light sensor.
DIP switches for user control.

Parts:
C4, C5, C6, C7: 1u; CP_Elec_8x10
D1, D2, D3, D5: SM4004; D_MELF
D4: 1SMB5956B-13; D_SMB
F1: 1A; Fuse_1206_3216Metric
J10: Conn_01x02_Pin; PinHeader_1x02_P2.54mm_Vertical_SMD_Pin1Right
L1: 10u; IND_BOURNS_SRR1280
Q1, Q2, Q3, Q4: PZTA42; SOT-223-3_TabPin2
R3: 1M; R_0603_1608Metric
R4: 10k; R_0603_1608Metric
R5, R6, R7, R8: 0.5; R_2010_5025Metric
TP1, TP2, TP3, TP4: TestPoint; TestPoint_Keystone_5019_Minature

Connections:
+5V: F1.1; also elsewhere on the board
/HV bleed/HV_{SENSE}: C6.1, D1.1 (K), D4.1 (K), J10.1, R3.1; also elsewhere on the board
/High voltage supply/5V_{BOOST-FUSE}: F1.2, L1.1
/High voltage supply/GATE_{HV}: Q1.1 (B), Q2.1 (B), Q3.1 (B), Q4.1 (B); also elsewhere on the board
/High voltage supply/HV_{FULL-BOOST}: C4.1, D1.2 (A), D2.1 (K), TP2.1
/High voltage supply/HV_{HALF-BOOST}: C4.2, C5.2, L1.2, Q1.2 (C), Q2.2 (C), Q3.2 (C), Q4.2 (C), TP1.1
/High voltage supply/HV_{HALF-SUPPLY}: C7.1, D2.2 (A), D3.1 (K), TP4.1
/High voltage supply/HV_{QUARTER-BOOST}: C5.1, D3.2 (A), D5.1 (K), TP3.1
/High voltage supply/MEASURE_{HV}: R3.2, R4.1; also elsewhere on the board
/High voltage supply/RE_{HV-1}: Q1.3 (E), R5.1
/High voltage supply/RE_{HV-2}: Q2.3 (E), R6.1
/High voltage supply/RE_{HV-3}: Q3.3 (E), R7.1
/High voltage supply/RE_{HV-4}: Q4.3 (E), R8.1
GND: C6.2, C7.2, D4.2 (A), D5.2 (A), R4.2, R5.2, R6.2, R7.2, R8.2; also elsewhere on the board
VPP: J10.2; also elsewhere on the board

Notes on the sheet:
Polyfuse input with 1A hold current and 1.8A trip current. Simulation shows this will hold up to 110 mA load and trip on 170 mA load. 12 Nixie tubes @ 2.8 mA each would be 33.6 mA worst case load. The goal is to allow max load driving while tripping on faults. This is limits the energy delivered to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
100:1 divider to bring (0-333.3 V) down to (0-3.3V) for feedback ADC
Inductor sizing captured in boost-convertor-calcs.xlsx.
200 V Zener to protect from over-voltage.
See ../../LTSpice/HV_supply_quadrupler.asc for simulation.
Some nixie power supplies online are based on single stage flyback with 1:10 transformers. Transformers are expensive and not well stocked compared to inductors. This boost convertor with voltage quadrupler resembles LT AN47 Appendix D with a voltage quadrupler (Art of Electronics 3E 1.6.5 Regulato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

Parts:
J1, J2, J3, J6, J7: Conn_01x02_Pin; PinHeader_1x02_P2.54mm_Vertical_SMD_Pin1Right
J4: pico iCE (A)
J5: pico iCE (B)
R1, R2: 1k; R_0603_1608Metric

Connections:
+3.3V: J1.2, R1.2, R2.2; also elsewhere on the board
+3.3V_STDBY: J7.1; also elsewhere on the board
+5V: J6.2; also elsewhere on the board
/GPS/GPS_{1PPS2}: J4.28 (ICE_45); also elsewhere on the board
/GPS/GPS_{1PPS}: J4.27 (ICE_44_G6); also elsewhere on the board
/GPS/GPS_{BOOT_SEL}: J5.29 (RP_18); also elsewhere on the board
/GPS/GPS_{RSTN}: J5.25 (RP_19); also elsewhere on the board
/GPS/GPS_{RXD}: J5.28 (RP_20); also elsewhere on the board
/GPS/GPS_{TXD}: J5.24 (RP_21); also elsewhere on the board
/High voltage supply/GATE_{HV}: J5.23 (RP_17); also elsewhere on the board
/High voltage supply/MEASURE_{HV}: J5.19 (RP_28_ADC2|PB); also elsewhere on the board
/LSD ADC/LSD_{ADC_D0}: J4.31 (ICE_48); also elsewhere on the board
/LSD ADC/LSD_{ADC_D1}: J4.29 (ICE_46); also elsewhere on the board
/LSD ADC/LSD_{ADC_D2}: J4.30 (ICE_47); also elsewhere on the board
/LSD ADC/LSD_{ADC_D3}: J4.19 (ICE_11); also elsewhere on the board
/LSD ADC/LSD_{ADC_D4}: J4.10 (ICE_31); also elsewhere on the board
/LSD ADC/LSD_{ADC_D5}: J4.12 (ICE_34); also elsewhere on the board
/LSD ADC/LSD_{ADC_D6}: J4.14 (ICE_38); also elsewhere on the board
/LSD ADC/LSD_{ADC_D7}: J4.16 (ICE_43); also elsewhere on the board
/LSD ADC/LSD_{ADC_MODE}: J4.13 (ICE_36); also elsewhere on the board
/LSD ADC/LSD_{ADC_~CS}: J4.9 (ICE_28); also elsewhere on the board
/LSD ADC/LSD_{ADC_~INT}: J4.20 (ICE_6); also elsewhere on the board
/LSD ADC/LSD_{ADC_~OFL}: J4.22 (ICE_9); also elsewhere on the board
/LSD ADC/LSD_{ADC_~RD}: J4.11 (ICE_32); also elsewhere on the board
/LSD ADC/LSD_{ADC_~WR/RDY}: J4.15 (ICE_42); also elsewhere on the board
/Nixies/CLOCK_{HV}: J4.34 (ICE_4); also elsewhere on the board
/Nixies/CLOCK_{PRECISE}: J5.8 (ICE_18/RP_7); also elsewhere on the board
/Nixies/DATA_{HV}: J4.33 (ICE_3); also elsewhere on the board
/Nixies/DATA_{PRECISE}: J5.7 (ICE_19/RP_3); also elsewhere on the board
/Nixies/PPS_{TRIMMED}: J5.12 (ICE_20_G3/RP_6); also elsewhere on the board
/Nixies/SENSE_{PRECISE}: J4.32 (ICE_2); also elsewhere on the board
/Peripherals/I2C_{CLOCK}: J5.6 (ICE_23/RP_5), R1.1; also elsewhere on the board
/Peripherals/I2C_{DATA}: J5.10 (ICE_26/RP_4), R2.1; also elsewhere on the board
/Peripherals/INT_{IO-expander}: J5.27 (RP_16); also elsewhere on the board
/Peripherals/brightness_control: J5.21 (RP_29_ADC3); also elsewhere on the board
/Peripherals/~RESET_{IO-expander}: J5.30 (RP_22); also elsewhere on the board
/Pico Ice/+3.3V_STDBY_SRAM_{SENSE}: J5.37 (+3V3_STDBY), J7.2
/Pico Ice/+3.3V_{SENSE}: J1.1, J4.5 (+3.3V), J4.6 (+3.3V), J5.15 (+3.3V), J5.16 (+3.3V), J5.33 (+3.3V), J5.34 (+3.3V), J5.35 (+3.3V)
/Pico Ice/+5V_{SENSE}: J5.36 (VBUS), J6.1
/Pico Ice/~ICE_RST: J2.1, J4.2 (RP_27/~ICE_RST)
/Pico Ice/~USB_BOOT: J3.1, J4.40 (~USB_BOOT)
GND: J2.2, J3.2, J4.4 (GND), J4.7 (GND), J4.8 (GND), J4.25 (GND), J4.26 (GND), J4.38 (GND), J5.13 (GND), J5.14 (GND), J5.31 (GND), J5.32 (GND), J5.40 (GND); also elsewhere on the board

## Commit log

2023-12-17 PICO-iCE v3 pin headers
2023-12-20 Connect pico iCE to GPS module
2023-12-21 Switch to discrete GPS module
    Switch from GPS daughter board to direct connection since it is so easy to implement, can save on cost, and is higher performance.
    Get project library stood up.
    Add proper mounting holes for pico ice and group components together.
2023-12-21 pretty models
2023-12-23 finish GPS module power and I/O
2023-12-23 Add USB-C model and silkscreen for installation aid
2023-12-23 Add high voltage supply
2023-12-23 Add DST controlling DIP switches
2023-12-23 add description of DST dipswitches on silk screen
2023-12-24 work on rules pass
2023-12-24 proper ERC and DRC pass
2023-12-26 First pass at requirements
2023-12-26 WIP nixies
2023-12-27 IN-14 daughter board
2023-12-27 WIP final feature push
2023-12-28 clean up placement and pin assignment
2023-12-28 reroute daughter board
    Swapped standoffs and pin header orientation on IN-14 daughter board so that standoffs face outward. This allows using the daughter board mounting for the mother board mounting.
2023-12-28 fix daughter board HV compat
    Increase copper weight on IN-14 daughter board to PCBWay's 4 layer 2 oz outer / 1.5 oz inner stackup. This has a 0.22 mm prepreg rather than 0.11 mm prepreg, which helps maintain 200 V clearance (0.2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
2023-12-28 simplify nixie daughter board
    Remove cathode pins that would not be usable for current sensing anyway.
    Pivot to using anode pin as shunt measurement with a R2R flash ADC (not yet implemented).
2023-12-29 Signal condition shunt signal
    Textbook reference and LTSpice simulation for receipts.
    I attempted a differential amplifier based solution but I failed to get it to work. If it did work it would require more components and likely give little additional benefit.
    ADC implementation WIP.
2023-12-29 fix clearance rules on daughter board
    0.4 mm clearance is not possible to obey with an HV driver IC package that has 0.25 mm pad spacing, but all HV lines can be kept at least 0.25 mm away from everything else and inner layers can be pre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
    WIP ADC interface, logic level convertor has been chosen.
2023-12-30 DRC pass except ADC
2023-12-30 give pico iCE better mounting
2023-12-30 ERC and DRC pass
2023-12-30 Add decoupling caps
2023-12-31 clean up decoupling caps
2023-12-31 WIP HV supply simulation
2023-12-31 fix sims
    SPICE asy files had improper netlist orders for their models
    FIxing this reveals that the LSD ADC circuit needed resistor tweaks, but now behaves much better (~70% of FS range for a 145 V nixie).
    The HV supply still does not sim properly. Will investigate a dedicated driver IC.
2023-12-31 Switch to <6 mil package for level shifting
2023-12-31 add delay resistor to level shifter OE
    Resistor is shown on TX0108 data sheet.
    Likely helps slow OE with capacitive input to help with power-on sequencing.
2023-12-31 tie level shift OE to ground
    OE on the TX0108 is internally tied high and should be softly pulled low for power-on sequencing.
2024-01-03 WIP two stage HV supply
2024-01-06 simulate HV supply concept
    LM5156 simulation is infeasible
    LTSpice model demonstrating that a two stage buck from 5 to 210 is possible. Both stages run away, but the LM5156 should provide feedback to keep it on target.
2024-01-06 HV bleed circuit
2024-01-07 Add HV control
    Stop tracking SPICE simulations
2024-01-07 finish schematic features
2024-01-08 ERC pass
    layout WIP
    All components arranged except power supplies.
    Most nets routed (all except power supplies and ADC lines).
2024-01-08 tear it apart again
    I didn't fix the pico iCE pinout after flipping it over.
    I still haven't, but routing is now a fresh start.
2024-01-08 fix pico iCE pinout
    Once and for all
2024-01-11 ERC pass
    Close look at pico iCE pinout
    Add light sensor
    Rough layout for non-HV
2024-01-11 20V rough layout
2024-01-12 DRC pass
    it's messy
2024-01-13 add pin assignments
    Pin assignment spreadsheet added
    IN-14 daughter board traces smoothed
2024-01-14 Fill out BOM
2024-01-14 change BOM filename
2024-01-14 Add retailer links
2024-01-14 adjust root schematic layout
2024-01-14 swap bleed resistor for SMD
2024-01-14 Add power budget
2024-01-14 Switch to SMT test points
2024-01-15 Add fiducials
2024-01-15 switch to 27k R_anode
    Add voltage rail jumpers for different 5V and 3.3V standby applications
2024-01-16 clean up pico iCE traces
2024-01-16 clean up SMPS routing
2024-01-16 finish routing cleanup
2024-01-16 inconsequential routing tweaks
2024-01-16 add board info to drawings
2024-01-17 configure outjobs
2024-01-17 remove renders from repo
2024-01-17 add licenses
2024-01-17 add IN-12 3D model
2024-01-17 remove old IN-12 models
2024-01-17 adjust IN-12 step filename
2024-01-18 Add fab/assembly notes
2024-01-18 add a few more notes
2024-01-18 BOM sync
2024-01-19 compress 20V SMPS
2024-01-19 clean up IN-14 teardrops
2024-01-20 round tracks plugin
2024-01-20 some trace cleanup
2024-01-20 change I2C pins
    Avoid conflict with RP2040/iCE UART
2024-01-21 initial FPGA software
    Blink LED
    Move folders around in repo for new paradigm
2024-01-21 add FPGA build script
2024-01-21 add some FPGA pinout names
2024-01-21 WIP MCU initial test
2024-01-21 remove file locks
2024-01-21 add RP2040 submodules
2024-01-22 get builds working
2024-01-22 WIP pinout config
2024-01-23 remove submodules
2024-01-23 add submodules back
2024-01-24 configure pinout
2024-01-24 move some files around
    temporarily remove submodules
2024-01-24 re-add submodules
2024-01-25 information about bad WSL python versions
2024-01-26 add thermal reliefs
2024-01-26 daughter board no TH components
2024-01-27 switch all components to SMT
    layout is a mess
2024-01-28 switch to all SM components
2024-02-05 switch to static level shifting
2024-02-12 WIP HV overhaul
2024-02-14 HV overhaul
    Parallel single stage boost convertor
    Need to find replacement MOSFET because SiB452BK footprint is too small for reasonable manufacturing and HV clearance.
2024-02-14 single stage HV supply
    Also switch to a MOSFET with a reasonable footprint
2024-02-22 proper HVPS
2024-02-23 lay out HVPS
2024-02-24 route nixie daughter boards
2024-02-24 WIP ADC routing
2024-02-24 update ADC pinout for improved routing
2024-02-24 DRC pass
2024-02-24 Rev B prep
2024-02-24 update IN-14 daughter board model
2024-02-25 pare back SW to essentials, switch to C++ main
2024-02-26 update to KiCAD 8
2024-02-26 Update date
2024-02-26 add standard views for renders
2024-03-06 add polyfuse to HVPS
    WIP hierarchy overhaul
2024-03-08 fuse HV, refactor schematic hierarchy
2024-03-08 adjust HV fuse pour
2024-03-09 fix TP1 silk screen
2024-03-23 Clean up clearances
    Set board clearances, add dimension annotations, clean up pour dimensions
2024-03-24 Switch to 2.4 mm stackup
    PCBWAY001 is cheaper than PCBWAY209 (2 oz copper) for 0.2 mm prepreg (200 V clearance)
2024-03-24 Switch to stackup PCBWAY206
    2.4 mm board is incompatible with SMA connector
    Clean up outdated board notes
2024-04-01 start work on enclosure
2024-04-02 temporarily remove zipped files
2024-04-02 add zippey for FCStd
2024-04-02 add smaller FCStd file back
2024-04-02 add larger FCStd back
    cull model details for 100 MB limit
2024-04-03 enclosure dev notes
2024-04-04 Create nixieAccurateClock-B-enclosure-protocase-U-4.5-1-6.75.FCStd
    Decent enclosure constraints and sketches, still unsure how to pocket the faces
2024-04-17 finish enclosure
2024-04-19 countersink bottom holes
2024-04-19 Add silk screen
2024-04-19 add alignment holes to 2x20 SM headers
2024-04-19 fix 2x1 SM header chirality
2024-05-07 fix compile
2024-05-25 get USB prinout working
2024-05-25 get ADCs reading
2024-05-27 update todo
2024-05-27 remove explicit cleaning from build script
2024-06-01 timers and threads
2024-06-01 add watchdog to HV control loop
2024-06-01 initial PWM work
2024-06-02 tune 1 kHz loop time, clear display on update
2024-06-02 more detailed build notes, drop HV divider by 10x
2026-01-03 Modify HV supply to attempt to solve weak IC
2026-01-04 add MacOS build info
2026-05-17 ignore /software/lib
