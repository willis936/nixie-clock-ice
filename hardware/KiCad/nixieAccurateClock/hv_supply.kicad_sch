File: hardware/KiCad/nixieAccurateClock/hv_supply.kicad_sch (KiCad schematic)
At the start: 28 parts, among them J10 Conn_01x02_Pin, Q2 BSP88, U6 LM51561HPWPR

Commit message: switch all components to SMT
layout is a mess
Parts:
- J10: footprint Connector_PinHeader_2.54mm:PinHeader_1x02_P2.54mm_Vertical -> Connector_PinHeader_2.54mm:PinHeader_1x02_P2.54mm_Vertical_SMD_Pin1Left; Digikey link https://www.digikey.com/en/products/detail/adam-tech/PH1-02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 -> https://www.digikey.com/en/products/detail/samtec-inc/TSM-1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; Model PH1-02-UA -> TSM-102-01-L-SV; Mouser link https://www.mouser.com/ProductDetail/Samtec/TSW-102-07-G-S?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 -> https://www.mouser.com/ProductDetail/Samtec/TSM-102-01-L-SV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; Price 0.10 -> 0.42
Changed lines of the file:
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@@
       (effects (font (size 1.27 1.27)) (justify right))
     )
-    (property "Footprint" "Connector_PinHeader_2.54mm:PinHeader_1x02_P2.54mm_Vertical" (at 213.36 52.07 0)
+    (property "Footprint" "Connector_PinHeader_2.54mm:PinHeader_1x02_P2.54mm_Vertical_SMD_Pin1Left" (at 213.36 52.07 0)
       (effects (font (size 1.27 1.27)) hide)
     )
-    (property "Datasheet" "https://app.adam-tech.com/products/download/data_sheet/201605/ph1-xx-ua-data-sheet.pdf" (at 213.36 52.07 0)
+    (property "Datasheet" "https://suddendocs.samtec.com/catalog_english/tsm.pdf" (at 213.36 52.07 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
       (effects (font (size 1.27 1.27)) hide)
     )
-    (property "Model" "PH1-02-UA" (at 213.36 52.07 0)
+    (property "Model" "TSM-102-01-L-SV" (at 213.36 52.07 0)
       (effects (font (size 1.27 1.27)) hide)
     )
-    (property "Price" "0.10" (at 213.36 52.07 0)
+    (property "Price" "0.42" (at 213.36 52.07 0)
       (effects (font (size 1.27 1.27)) hide)
     )
-    (property "Digikey link" "https://www.digikey.com/en/products/detail/adam-tech/PH1-02-UA/9830266" (at 213.36 52.07 0)
+    (property "Digikey link" "https://www.digikey.com/en/products/detail/samtec-inc/TSM-102-01-L-SV/2685520" (at 213.36 52.07 0)
       (effects (font (size 1.27 1.27)) hide)
     )
-    (property "Mouser link" "https://www.mouser.com/ProductDetail/Samtec/TSW-102-07-G-S?qs=iT52DjcXudsNPhlNCDp8vw%3D%3D" (at 213.36 52.07 0)
+    (property "Mouser link" "https://www.mouser.com/ProductDetail/Samtec/TSM-102-01-L-SV?qs=FESYatJ8odJ%252BIhPvKBkuBA%3D%3D" (at 213.36 52.07 0)
       (effects (font (size 1.27 1.27)) hide)
     )

Commit message: switch to all SM components
Parts:
- renumbered J10 to J12, U6 to U5
Changed lines of the file:
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@@
   (symbol (lib_id "00_lib:+20V") (at 144.78 44.45 90) (unit 1)
     (in_bom no) (on_board no) (dnp no) (fields_autoplaced)
-    (property "Reference" "#PWR042" (at 147.32 44.45 0)
+    (property "Reference" "#PWR059" (at 147.32 44.45 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
       (project "nixieAccurateClock"
         (path "/55aab698-7558-4fe2-95ad-faa6da60ef89/f2852417-d6c8-4bbe-bd15-a29bc4083bd0"
-          (reference "#PWR042") (unit 1)
+          (reference "#PWR059") (unit 1)
         )
       )
@@
   (symbol (lib_id "power:GND") (at 111.76 90.17 90) (unit 1)
     (in_bom yes) (on_board yes) (dnp no) (fields_autoplaced)
-    (property "Reference" "#PWR050" (at 118.11 90.17 0)
+    (property "Reference" "#PWR067" (at 118.11 90.17 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
       (project "nixieAccurateClock"
         (path "/55aab698-7558-4fe2-95ad-faa6da60ef89/f2852417-d6c8-4bbe-bd15-a29bc4083bd0"
-          (reference "#PWR050") (unit 1)
+          (reference "#PWR067") (unit 1)
         )
       )
@@
   (symbol (lib_id "power:GND") (at 24.13 52.07 270) (unit 1)
     (in_bom yes) (on_board yes) (dnp no) (fields_autoplaced)
-    (property "Reference" "#PWR043" (at 17.78 52.07 0)
+    (property "Reference" "#PWR060" (at 17.78 52.07 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
       (project "nixieAccurateClock"
         (path "/55aab698-7558-4fe2-95ad-faa6da60ef89/f2852417-d6c8-4bbe-bd15-a29bc4083bd0"
-          (reference "#PWR043") (unit 1)
+          (reference "#PWR060") (unit 1)
         )
       )
@@
   (symbol (lib_id "power:GND") (at 236.22 69.85 0) (unit 1)
     (in_bom yes) (on_board yes) (dnp no) (fields_autoplaced)
-    (property "Reference" "#PWR046" (at 236.22 76.2 0)
+    (property "Reference" "#PWR063" (at 236.22 76.2 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
       (project "nixieAccurateClock"
         (path "/55aab698-7558-4fe2-95ad-faa6da60ef89/f2852417-d6c8-4bbe-bd15-a29bc4083bd0"
-          (reference "#PWR046") (unit 1)
+          (reference "#PWR063") (unit 1)
         )
       )
@@
   (symbol (lib_id "power:GND") (at 184.15 104.14 0) (unit 1)
     (in_bom yes) (on_board yes) (dnp no) (fields_autoplaced)
-    (property "Reference" "#PWR052" (at 184.15 110.49 0)
+    (property "Reference" "#PWR069" (at 184.15 110.49 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
       (project "nixieAccurateClock"
         (path "/55aab698-7558-4fe2-95ad-faa6da60ef89/f2852417-d6c8-4bbe-bd15-a29bc4083bd0"
-          (reference "#PWR052") (unit 1)
+          (reference "#PWR069") (unit 1)
         )
       )
@@
   (symbol (lib_id "power:GND") (at 198.12 60.96 0) (unit 1)
     (in_bom yes) (on_board yes) (dnp no) (fields_autoplaced)
-    (property "Reference" "#PWR045" (at 198.12 67.31 0)
+    (property "Reference" "#PWR062" (at 198.12 67.31 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
       (project "nixieAccurateClock"
         (path "/55aab698-7558-4fe2-95ad-faa6da60ef89/f2852417-d6c8-4bbe-bd15-a29bc4083bd0"
-          (reference "#PWR045") (unit 1)
+          (reference "#PWR062") (unit 1)
         )
       )
@@
   (symbol (lib_id "power:GND") (at 160.02 73.66 0) (unit 1)
     (in_bom yes) (on_board yes) (dnp no) (fields_autoplaced)
-    (property "Reference" "#PWR047" (at 160.02 80.01 0)
+    (property "Reference" "#PWR064" (at 160.02 80.01 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
       (project "nixieAccurateClock"
         (path "/55aab698-7558-4fe2-95ad-faa6da60ef89/f2852417-d6c8-4bbe-bd15-a29bc4083bd0"
-          (reference "#PWR047") (unit 1)
+          (reference "#PWR064") (unit 1)
         )
       )
@@
   (symbol (lib_id "power:GND") (at 48.26 74.93 270) (unit 1)
     (in_bom yes) (on_board yes) (dnp no) (fields_autoplaced)
-    (property "Reference" "#PWR048" (at 41.91 74.93 0)
+    (property "Reference" "#PWR065" (at 41.91 74.93 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
       (project "nixieAccurateClock"
         (path "/55aab698-7558-4fe2-95ad-faa6da60ef89/f2852417-d6c8-4bbe-bd15-a29bc4083bd0"
-          (reference "#PWR048") (unit 1)
+          (reference "#PWR065") (unit 1)
         )
       )
@@
   (symbol (lib_id "power:GND") (at 48.26 82.55 270) (unit 1)
     (in_bom yes) (on_board yes) (dnp no) (fields_autoplaced)
-    (property "Reference" "#PWR049" (at 41.91 82.55 0)
+    (property "Reference" "#PWR066" (at 41.91 82.55 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
       (project "nixieAccurateClock"
         (path "/55aab698-7558-4fe2-95ad-faa6da60ef89/f2852417-d6c8-4bbe-bd15-a29bc4083bd0"
-          (reference "#PWR049") (unit 1)
+          (reference "#PWR066") (unit 1)
         )
       )
@@
   (symbol (lib_id "power:GND") (at 60.96 59.69 270) (unit 1)
     (in_bom yes) (on_board yes) (dnp no) (fields_autoplaced)
-    (property "Reference" "#PWR044" (at 54.61 59.69 0)
+    (property "Reference" "#PWR061" (at 54.61 59.69 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
       (project "nixieAccurateClock"
         (path "/55aab698-7558-4fe2-95ad-faa6da60ef89/f2852417-d6c8-4bbe-bd15-a29bc4083bd0"
-          (reference "#PWR044") (unit 1)
+          (reference "#PWR061") (unit 1)
         )
       )
@@
   (symbol (lib_id "00_lib:LM51561HPWPR") (at 64.77 44.45 0) (unit 1)
     (in_bom yes) (on_board yes) (dnp no)
-    (property "Reference" "U6" (at 86.36 34.29 0)
+    (property "Reference" "U5" (at 86.36 34.29 0)
       (effects (font (size 1.524 1.524)))
     )
@@
       (project "nixieAccurateClock"
         (path "/55aab698-7558-4fe2-95ad-faa6da60ef89/f2852417-d6c8-4bbe-bd15-a29bc4083bd0"
-          (reference "U6") (unit 1)
+          (reference "U5") (unit 1)
         )
       )
@@
   (symbol (lib_id "power:GND") (at 121.92 44.45 90) (unit 1)
     (in_bom yes) (on_board yes) (dnp no)
-    (property "Reference" "#PWR041" (at 128.27 44.45 0)
+    (property "Reference" "#PWR058" (at 128.27 44.45 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
       (project "nixieAccurateClock"
         (path "/55aab698-7558-4fe2-95ad-faa6da60ef89/f2852417-d6c8-4bbe-bd15-a29bc4083bd0"
-          (reference "#PWR041") (unit 1)
+          (reference "#PWR058") (unit 1)
         )
       )
@@
   (symbol (lib_id "Connector:Conn_01x02_Pin") (at 213.36 52.07 90) (unit 1)
     (in_bom yes) (on_board yes) (dnp no)
-    (property "Reference" "J10" (at 217.17 50.165 90)
+    (property "Reference" "J12" (at 217.17 50.165 90)
       (effects (font (size 1.27 1.27)) (justify right))
     )
@@
       (project "nixieAccurateClock"
         (path "/55aab698-7558-4fe2-95ad-faa6da60ef89/f2852417-d6c8-4bbe-bd15-a29bc4083bd0"
-          (reference "J10") (unit 1)
+          (reference "J12") (unit 1)
         )
       )
@@
   (symbol (lib_id "power:GND") (at 138.43 100.33 0) (unit 1)
     (in_bom yes) (on_board yes) (dnp no) (fields_autoplaced)
-    (property "Reference" "#PWR051" (at 138.43 106.68 0)
+    (property "Reference" "#PWR068" (at 138.43 106.68 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
       (project "nixieAccurateClock"
         (path "/55aab698-7558-4fe2-95ad-faa6da60ef89/f2852417-d6c8-4bbe-bd15-a29bc4083bd0"
-          (reference "#PWR051") (unit 1)
+          (reference "#PWR068") (unit 1)
         )
       )
@@
   (symbol (lib_id "power:VPP") (at 236.22 41.91 0) (unit 1)
     (in_bom yes) (on_board yes) (dnp no) (fields_autoplaced)
-    (property "Reference" "#PWR039" (at 236.22 45.72 0)
+    (property "Reference" "#PWR056" (at 236.22 45.72 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
       (project "nixieAccurateClock"
         (path "/55aab698-7558-4fe2-95ad-faa6da60ef89/f2852417-d6c8-4bbe-bd15-a29bc4083bd0"
-          (reference "#PWR039") (unit 1)
+          (reference "#PWR056") (unit 1)
         )
       )
@@
   (symbol (lib_id "00_lib:+20V") (at 24.13 44.45 90) (unit 1)
     (in_bom no) (on_board no) (dnp no) (fields_autoplaced)
-    (property "Reference" "#PWR040" (at 26.67 44.45 0)
+    (property "Reference" "#PWR057" (at 26.67 44.45 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
       (project "nixieAccurateClock"
         (path "/55aab698-7558-4fe2-95ad-faa6da60ef89/f2852417-d6c8-4bbe-bd15-a29bc4083bd0"
-          (reference "#PWR040") (unit 1)
-        )
-      )
+          (reference "#PWR057") (unit 1)
+        )
+      )

Commit message: HV overhaul
Parallel single stage boost convertor
Need to find replacement MOSFET because SiB452BK footprint is too small for reasonable manufacturing and HV clearance.
Parts:
- removed C10: 10u, Capacitor_SMD:CP_Elec_8x10, symbol Device:C_Polarized
- removed C11, C13, C9: 1u, Capacitor_SMD:C_0603_1608Metric, symbol Device:C
- removed C12: 1n, Capacitor_SMD:C_0603_1608Metric, symbol Device:C
- removed C14: 0.1u, Capacitor_SMD:C_0603_1608Metric, symbol Device:C_Small
- removed D2: SM4004, Diode_SMD:D_MELF, symbol Diode:SM4004
- removed L2: 820u, 00_lib:IND_MSS1583_COC, symbol Device:L
- removed Q2: BSP88, Package_TO_SOT_SMD:SOT-223-3_TabPin2, symbol 00_lib:BSP88
- removed R11: 62k, Resistor_SMD:R_0603_1608Metric, symbol Device:R
- removed R13: 4.7k, Resistor_SMD:R_0603_1608Metric, symbol Device:R
- removed R14, R15: 1k, Resistor_SMD:R_0603_1608Metric, symbol Device:R
- removed R17: 40m, Resistor_SMD:R_0603_1608Metric, symbol Device:R
- removed R18, R22: 100k, Resistor_SMD:R_0603_1608Metric, symbol Device:R
- removed R19: 220k, Resistor_SMD:R_0603_1608Metric, symbol Device:R
- removed R20: 2.7M, Resistor_SMD:R_0603_1608Metric, symbol Device:R
- removed R21: 10k, Resistor_SMD:R_0603_1608Metric, symbol Device:R
- removed R23: 15k, Resistor_SMD:R_0603_1608Metric, symbol Device:R
- removed TP10, TP7, TP8, TP9: TestPoint, 00_lib:TestPoint_Keystone_5019_Minature, symbol Connector:TestPoint
- removed U5: LM51561HPWPR, 00_lib:PWP0014H-IPC_C, symbol 00_lib:LM51561HPWPR
- renumbered J12 to J10, R12 to R3, R16 to R4
Connections:
- net HV_{MEASURE} renamed MEASURE_{HV}
Other:
- added sheet Boost Quadrupler 1 (Boost_quad.kicad_sch)
- added sheet Boost Quadrupler 2 (Boost_quad.kicad_sch)
- moved on the sheet: J10, R3, R4

Commit message: single stage HV supply
Also switch to a MOSFET with a reasonable footprint
Other:
- removed sheet Boost Quadrupler 2
Changed lines of the file:
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@@
-    )
-  )
-  (sheet (at 24.13 29.21) (size 12.7 3.81) (fields_autoplaced)
-    (stroke (width 0.1524) (type solid))
-    (fill (color 0 0 0 0.0000))
-    (property "Sheetname" "Boost Quadrupler 2" (at 24.13 28.4984 0)
-      (effects (font (size 1.27 1.27)) (justify left bottom))
-    )
-    (property "Sheetfile" "Boost_quad.kicad_sch" (at 24.13 33.6046 0)
-      (effects (font (size 1.27 1.27)) (justify left top))
-    )
-    (instances
-      (project "nixieAccurateClock"
-        (path "/55aab698-7558-4fe2-95ad-faa6da60ef89/f2852417-d6c8-4bbe-bd15-a29bc4083bd0" (page "5"))
-      )
     )
   )
