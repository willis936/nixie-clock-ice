File: hardware/KiCad/nixieAccurateClock/HV_bleed.kicad_sch (KiCad schematic)
At the start: 10 parts, among them Q5 PZTA42, Q6 PZTA42

Commit message: Modify HV supply to attempt to solve weak IC
