File: hardware/KiCad/nixieAccurateClock/peripherals.kicad_sch (KiCad schematic)
At the start: 6 parts, among them SW1 SW_DIP_x08, U1 MCP23008-xSO, U2 LTR-329ALS-01

Commit message: Modify HV supply to attempt to solve weak IC
