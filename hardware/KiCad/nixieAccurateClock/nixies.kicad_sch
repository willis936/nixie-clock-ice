File: hardware/KiCad/nixieAccurateClock/nixies.kicad_sch (KiCad schematic)
At the start: 7 parts, among them J17 Conn_02x05_Odd_Even

Commit message: fuse HV, refactor schematic hierarchy
