File: KiCad/nixieAccurateClock/hv_supply.kicad_sch (KiCad schematic)
At the start: 32 parts, among them J9 Conn_01x02_Pin, Q2 BSP88, U6 LM51561HPWPR

Commit message: DRC pass
it's messy
Parts:
- removed TP11, TP15: TestPoint, TestPoint:TestPoint_Loop_D2.54mm_Drill1.5mm_Beaded, symbol Connector:TestPoint
- R11, R14, R15, R17: footprint Resistor_SMD:R_0201_0603Metric -> Resistor_SMD:R_0603_1608Metric
- renumbered TP12 to TP11, TP13 to TP12, TP14 to TP13
Changed lines of the file:
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@@
+    (stroke (width 0) (type default))
+  )
+  (wire (pts (xy 198.12 41.91) (xy 198.12 44.45))
     (stroke (width 0) (type default))
   )
@@
     (stroke (width 0) (type default))
   )
-  (wire (pts (xy 223.52 104.14) (xy 223.52 101.6))
-    (stroke (width 0) (type default))
-  )
   (wire (pts (xy 124.46 73.66) (xy 124.46 74.93))
     (stroke (width 0) (type default))
   )
   (wire (pts (xy 26.67 52.07) (xy 24.13 52.07))
-    (stroke (width 0) (type default))
-  )
-  (wire (pts (xy 232.41 57.15) (xy 236.22 57.15))
     (stroke (width 0) (type default))
   )
@@
   )
   (label "HV_{CS}" (at 109.22 59.69 0) (fields_autoplaced)
-    (effects (font (size 1.27 1.27)) (justify left bottom))
-  )
-  (label "HV_{SENSE}" (at 203.2 44.45 0) (fields_autoplaced)
     (effects (font (size 1.27 1.27)) (justify left bottom))
   )
@@
     )
   )
+  (global_label "HV_{SENSE}" (shape output) (at 198.12 41.91 90) (fields_autoplaced)
+    (effects (font (size 1.27 1.27)) (justify left))
+    (property "Intersheetrefs" "${INTERSHEET_REFS}" (at 198.12 31.6169 90)
+      (effects (font (size 1.27 1.27)) (justify left) hide)
+    )
+  )
   (symbol (lib_id "Device:R") (at 160.02 66.04 0) (mirror y) (unit 1)
     (in_bom yes) (on_board yes) (dnp no)
@@
       (effects (font (size 1.27 1.27)))
     )
-    (property "Footprint" "Resistor_SMD:R_0201_0603Metric" (at 161.798 66.04 90)
+    (property "Footprint" "Resistor_SMD:R_0603_1608Metric" (at 161.798 66.04 90)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
     )
   )
-  (symbol (lib_id "power:GND") (at 223.52 104.14 0) (unit 1)
-    (in_bom yes) (on_board yes) (dnp no) (fields_autoplaced)
-    (property "Reference" "#PWR054" (at 223.52 110.49 0)
-      (effects (font (size 1.27 1.27)) hide)
-    )
-    (property "Value" "GND" (at 223.52 109.22 0)
-      (effects (font (size 1.27 1.27)))
-    )
-    (property "Footprint" "" (at 223.52 104.14 0)
-      (effects (font (size 1.27 1.27)) hide)
-    )
-    (property "Datasheet" "" (at 223.52 104.14 0)
-      (effects (font (size 1.27 1.27)) hide)
-    )
-    (pin "1")
-    (instances
-      (project "nixieAccurateClock"
-        (path "/55aab698-7558-4fe2-95ad-faa6da60ef89/f2852417-d6c8-4bbe-bd15-a29bc4083bd0"
-          (reference "#PWR054") (unit 1)
-        )
-      )
-    )
-  )
   (symbol (lib_id "power:GND") (at 24.13 52.07 270) (unit 1)
     (in_bom yes) (on_board yes) (dnp no) (fields_autoplaced)
@@
   (symbol (lib_id "Connector:TestPoint") (at 124.46 66.04 0) (unit 1)
     (in_bom yes) (on_board yes) (dnp no) (fields_autoplaced)
-    (property "Reference" "TP13" (at 127 61.468 0)
+    (property "Reference" "TP12" (at 127 61.468 0)
       (effects (font (size 1.27 1.27)) (justify left))
     )
@@
       (project "nixieAccurateClock"
         (path "/55aab698-7558-4fe2-95ad-faa6da60ef89/f2852417-d6c8-4bbe-bd15-a29bc4083bd0"
-          (reference "TP13") (unit 1)
+          (reference "TP12") (unit 1)
         )
       )
@@
       (effects (font (size 1.27 1.27)))
     )
-    (property "Footprint" "Resistor_SMD:R_0201_0603Metric" (at 65.278 48.26 90)
+    (property "Footprint" "Resistor_SMD:R_0603_1608Metric" (at 65.278 48.26 90)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
   (symbol (lib_id "Connector:TestPoint") (at 41.91 64.77 0) (unit 1)
     (in_bom yes) (on_board yes) (dnp no) (fields_autoplaced)
-    (property "Reference" "TP12" (at 44.45 60.198 0)
+    (property "Reference" "TP11" (at 44.45 60.198 0)
       (effects (font (size 1.27 1.27)) (justify left))
     )
@@
       (project "nixieAccurateClock"
         (path "/55aab698-7558-4fe2-95ad-faa6da60ef89/f2852417-d6c8-4bbe-bd15-a29bc4083bd0"
-          (reference "TP12") (unit 1)
+          (reference "TP11") (unit 1)
         )
       )
@@
         (path "/55aab698-7558-4fe2-95ad-faa6da60ef89/f2852417-d6c8-4bbe-bd15-a29bc4083bd0"
           (reference "R12") (unit 1)
-        )
-      )
-    )
-  )
-  (symbol (lib_id "Connector:TestPoint") (at 223.52 101.6 0) (unit 1)
-    (in_bom yes) (on_board yes) (dnp no) (fields_autoplaced)
-    (property "Reference" "TP15" (at 226.06 97.028 0)
-      (effects (font (size 1.27 1.27)) (justify left))
-    )
-    (property "Value" "TestPoint" (at 226.06 99.568 0)
-      (effects (font (size 1.27 1.27)) (justify left))
-    )
-    (property "Footprint" "TestPoint:TestPoint_Loop_D2.54mm_Drill1.5mm_Beaded" (at 228.6 101.6 0)
-      (effects (font (size 1.27 1.27)) hide)
-    )
-    (property "Datasheet" "https://www.keyelco.com/userAssets/file/M65p56.pdf" (at 228.6 101.6 0)
-      (effects (font (size 1.27 1.27)) hide)
-    )
-    (property "Model" "5001" (at 223.52 101.6 0)
-      (effects (font (size 1.27 1.27)) hide)
-    )
-    (property "Sim.Enable" "0" (at 223.52 101.6 0)
-      (effects (font (size 1.27 1.27)) hide)
-    )
-    (pin "1")
-    (instances
-      (project "nixieAccurateClock"
-        (path "/55aab698-7558-4fe2-95ad-faa6da60ef89/f2852417-d6c8-4bbe-bd15-a29bc4083bd0"
-          (reference "TP15") (unit 1)
         )
       )
@@
     )
   )
-  (symbol (lib_id "Connector:TestPoint") (at 232.41 57.15 90) (mirror x) (unit 1)
-    (in_bom yes) (on_board yes) (dnp no)
-    (property "Reference" "TP11" (at 229.108 62.23 90)
-      (effects (font (size 1.27 1.27)))
-    )
-    (property "Value" "TestPoint" (at 229.108 59.69 90)
-      (effects (font (size 1.27 1.27)))
-    )
-    (property "Footprint" "TestPoint:TestPoint_Loop_D2.54mm_Drill1.5mm_Beaded" (at 232.41 62.23 0)
-      (effects (font (size 1.27 1.27)) hide)
-    )
-    (property "Datasheet" "https://www.keyelco.com/userAssets/file/M65p56.pdf" (at 232.41 62.23 0)
-      (effects (font (size 1.27 1.27)) hide)
-    )
-    (property "Model" "5001" (at 232.41 57.15 0)
-      (effects (font (size 1.27 1.27)) hide)
-    )
-    (property "Sim.Enable" "0" (at 232.41 57.15 0)
-      (effects (font (size 1.27 1.27)) hide)
-    )
-    (pin "1")
-    (instances
-      (project "nixieAccurateClock"
-        (path "/55aab698-7558-4fe2-95ad-faa6da60ef89/f2852417-d6c8-4bbe-bd15-a29bc4083bd0"
-          (reference "TP11") (unit 1)
-        )
-      )
-    )
-  )
   (symbol (lib_id "Device:R") (at 138.43 80.01 0) (unit 1)
     (in_bom yes) (on_board yes) (dnp no) (fields_autoplaced)
@@
   (symbol (lib_id "Connector:TestPoint") (at 124.46 73.66 0) (unit 1)
     (in_bom yes) (on_board yes) (dnp no) (fields_autoplaced)
-    (property "Reference" "TP14" (at 127 69.088 0)
+    (property "Reference" "TP13" (at 127 69.088 0)
       (effects (font (size 1.27 1.27)) (justify left))
     )
@@
       (project "nixieAccurateClock"
         (path "/55aab698-7558-4fe2-95ad-faa6da60ef89/f2852417-d6c8-4bbe-bd15-a29bc4083bd0"
-          (reference "TP14") (unit 1)
+          (reference "TP13") (unit 1)
         )
       )
@@
       (effects (font (size 1.27 1.27)))
     )
-    (property "Footprint" "Resistor_SMD:R_0201_0603Metric" (at 134.62 61.468 90)
+    (property "Footprint" "Resistor_SMD:R_0603_1608Metric" (at 134.62 61.468 90)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
       (effects (font (size 1.27 1.27)))
     )
-    (property "Footprint" "Resistor_SMD:R_0201_0603Metric" (at 118.11 61.468 90)
-      (effects (font (size 1.27 1.27)) hide)
-    )
+    (property "Footprint" "Resistor_SMD:R_0603_1608Metric" (at 118.11 61.468 90)
+      (effects (font (size 1.27 1.27)) hide)
+    )

Commit message: add pin assignments
Pin assignment spreadsheet added
IN-14 daughter board traces smoothed
Changed lines of the file:
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@@
+    (effects (font (size 1.27 1.27)) (justify left top))
+  )
+  (text_box "See ../../LTSpice/HV_control.asc for simulation."
+    (at 140.97 116.84 0) (size 50.8 3.81)
+    (stroke (width 0) (type default))
+    (fill (type none))
     (effects (font (size 1.27 1.27)) (justify left top))
   )

Commit message: Fill out BOM
Parts:
- C10: Price (none) -> 1.03
- C11, C13, C9, R11, R20, R23: Price (none) -> 0.10
- C12: Model (none) -> C0603C102K5RAC7867; Price (none) -> 0.10
- C14: Model (none) -> CL10B104KB8NNWC; Price (none) -> 0.10
- D2: Model (none) -> SM4004; Price (none) -> 0.27
- J8: renamed from J9; Model (none) -> PH1-02-UA; Price (none) -> 0.10
- L2: Price (none) -> 4.07
- Q2: Model (none) -> BSP88; Price (none) -> 0.60
- R12: Model (none) -> RMCF0603FT10M0; Price (none) -> 0.10
- R13: Model (none) -> RC0603JR-074K7L; Price (none) -> 0.10
- R14, R15: Model (none) -> RC0603FR-071KL; Price (none) -> 0.10
- R16, R18, R22: Model (none) -> RC0603JR-07100KL; Price (none) -> 0.10
- R17: Price (none) -> 0.74
- R19: Model (none) -> RMCF0603FT220K; Price (none) -> 0.10
- R21: Model (none) -> RC0603FR-0710KL; Price (none) -> 0.10
- TP10, TP11, TP12, TP13, TP9: Price (none) -> 0.38
- TP8: Price (none) -> 0.38; now fitted
- U6: Model (none) -> LM51561HPWPR; Price (none) -> 2.18

Commit message: Add retailer links
Parts:
- C10: Digikey link (none) -> https://www.digikey.com/en/products/detail/nichicon/UVC2G10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; Mouser link (none) -> https://www.mouser.com/ProductDetail/Nichicon/UVC2G100MPD1T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
- C11, C13, C14, C9: Digikey link (none) -> https://www.digikey.com/en/products/detail/samsung-electro-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; Mouser link (none) -> https://www.mouser.com/ProductDetail/Samsung-Electro-Mechan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
- C12: Digikey link (none) -> https://www.digikey.com/en/products/detail/kemet/C0603C102K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; Mouser link (none) -> https://www.mouser.com/ProductDetail/KEMET/C0603C102K5RAC78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
- D2: Digikey link (none) -> https://www.digikey.com/en/products/detail/diotec-semicondu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; Mouser link (none) -> https://www.mouser.com/ProductDetail/Diotec-Semiconductor/S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
- J8: Digikey link (none) -> https://www.digikey.com/en/products/detail/adam-tech/PH1-02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; Mouser link (none) -> https://www.mouser.com/ProductDetail/Samtec/TSW-102-07-G-S?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
- L2: Digikey link (none) -> N/A; Mouser link (none) -> https://www.mouser.com/ProductDetail/Coilcraft/MSS1583-824K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
- Q2: Digikey link (none) -> https://www.digikey.com/en/products/detail/infineon-technol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; Mouser link (none) -> https://www.mouser.com/ProductDetail/Infineon-Technologies/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
- R11: Digikey link (none) -> https://www.digikey.com/en/products/detail/stackpole-electr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; Mouser link (none) -> https://www.mouser.com/ProductDetail/Panasonic/ERJ-3GEYJ623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
- R12, R19: Digikey link (none) -> https://www.digikey.com/en/products/detail/stackpole-electr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; Mouser link (none) -> https://www.mouser.com/ProductDetail/SEI-Stackpole/RMCF0603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
- R13: Digikey link (none) -> https://www.digikey.com/en/products/detail/yageo/RC0603JR-0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; Mouser link (none) -> https://www.mouser.com/ProductDetail/YAGEO/RC0603JR-074K7L?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
- R14, R15: Digikey link (none) -> https://www.digikey.com/en/products/detail/yageo/RC0603FR-0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; Mouser link (none) -> https://www.mouser.com/ProductDetail/YAGEO/RC0603FR-071KL?q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
- R16, R18, R22: Digikey link (none) -> https://www.digikey.com/en/products/detail/yageo/RC0603JR-0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; Mouser link (none) -> https://www.mouser.com/ProductDetail/YAGEO/RC0603JR-07100KL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
- R17: Digikey link (none) -> https://www.digikey.com/en/products/detail/vishay-dale/WSLP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; Mouser link (none) -> https://www.mouser.com/ProductDetail/Vishay-Dale/WSLP0603R0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
- R20: Digikey link (none) -> https://www.digikey.com/en/products/detail/yageo/RC0603JR-0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; Mouser link (none) -> https://www.mouser.com/ProductDetail/YAGEO/RC0603JR-072M7L?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
- R21: Digikey link (none) -> https://www.digikey.com/en/products/detail/yageo/RC0603FR-0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; Mouser link (none) -> https://www.mouser.com/ProductDetail/YAGEO/RC0603FR-0710KL?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
- R23: Digikey link (none) -> https://www.digikey.com/en/products/detail/yageo/RC0603FR-0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; Mouser link (none) -> https://www.mouser.com/ProductDetail/YAGEO/RC0603FR-071K5L?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
- TP10, TP11, TP12, TP13, TP8, TP9: Digikey link (none) -> https://www.digikey.com/en/products/detail/keystone-electro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; Mouser link (none) -> https://www.mouser.com/ProductDetail/Keystone-Electronics/5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
- U6: Digikey link (none) -> https://www.digikey.com/en/products/detail/texas-instrument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; Mouser link (none) -> https://www.mouser.com/ProductDetail/Texas-Instruments/LM51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

Commit message: Switch to SMT test points
Parts:
- TP10, TP11, TP12, TP13, TP8, TP9: footprint TestPoint:TestPoint_Loop_D2.54mm_Drill1.5mm_Beaded -> 00_lib:TestPoint_Keystone_5019_Minature; Digikey link https://www.digikey.com/en/products/detail/keystone-electronics/5001/255327 -> https://www.digikey.com/en/products/detail/keystone-electronics/5019/3907343; Model 5001 -> 5019; Mouser link https://www.mouser.com/ProductDetail/Keystone-Electronics/5001?qs=q0tsjPZWdm%2FW0vdr%2FwowKg%3D%3D -> https://www.mouser.com/ProductDetail/Keystone-Electronics/5019?qs=wOxb8XianXjjCAsb90Ilzw%3D%3D; Price 0.38 -> 0.33

Commit message: switch to 27k R_anode
Add voltage rail jumpers for different 5V and 3.3V standby applications
Parts:
- renumbered J8 to J10
Changed lines of the file:
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@@
   (symbol (lib_id "Connector:Conn_01x02_Pin") (at 213.36 52.07 90) (unit 1)
     (in_bom yes) (on_board yes) (dnp no)
-    (property "Reference" "J8" (at 217.17 50.165 90)
+    (property "Reference" "J10" (at 217.17 50.165 90)
       (effects (font (size 1.27 1.27)) (justify right))
     )
@@
       (project "nixieAccurateClock"
         (path "/55aab698-7558-4fe2-95ad-faa6da60ef89/f2852417-d6c8-4bbe-bd15-a29bc4083bd0"
-          (reference "J8") (unit 1)
+          (reference "J10") (unit 1)
         )
       )

Commit message: clean up pico iCE traces
Parts:
- C10: footprint Capacitor_THT:CP_Radial_D10.0mm_P5.00mm -> Capacitor_SMD:CP_Elec_8x10; Digikey link https://www.digikey.com/en/products/detail/nichicon/UVC2G10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 -> https://www.digikey.com/en/products/detail/nichicon/ULR2E10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; Model UVC2G100MPD1TD -> ULR2E100MNL1GS; Mouser link https://www.mouser.com/ProductDetail/Nichicon/UVC2G100MPD1T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 -> https://www.mouser.com/ProductDetail/Nichicon/ULR2E100MNL1G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; Price 1.03 -> 0.99
Changed lines of the file:
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@@
       (effects (font (size 1.27 1.27)) (justify left))
     )
-    (property "Footprint" "Capacitor_THT:CP_Radial_D10.0mm_P5.00mm" (at 199.0852 55.88 0)
+    (property "Footprint" "Capacitor_SMD:CP_Elec_8x10" (at 199.0852 55.88 0)
       (effects (font (size 1.27 1.27)) hide)
     )
-    (property "Datasheet" "https://www.nichicon.co.jp/english/products/pdfs/e-uvc.pdf" (at 198.12 52.07 0)
+    (property "Datasheet" "https://www.nichicon.co.jp/english/series_items/catalog_pdf/e-ulr.pdf" (at 198.12 52.07 0)
       (effects (font (size 1.27 1.27)) hide)
     )
-    (property "Model" "UVC2G100MPD1TD" (at 198.12 52.07 0)
+    (property "Model" "ULR2E100MNL1GS" (at 198.12 52.07 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
       (effects (font (size 1.27 1.27)) hide)
     )
-    (property "Price" "1.03" (at 198.12 52.07 0)
+    (property "Price" "0.99" (at 198.12 52.07 0)
       (effects (font (size 1.27 1.27)) hide)
     )
-    (property "Digikey link" "https://www.digikey.com/en/products/detail/nichicon/UVC2G100MPD1TD/4312415" (at 198.12 52.07 0)
+    (property "Digikey link" "https://www.digikey.com/en/products/detail/nichicon/ULR2E100MNL1GS/3664123" (at 198.12 52.07 0)
       (effects (font (size 1.27 1.27)) hide)
     )
-    (property "Mouser link" "https://www.mouser.com/ProductDetail/Nichicon/UVC2G100MPD1TD?qs=dHDuPHwQO7%2FySlLjjH7nrA%3D%3D" (at 198.12 52.07 0)
+    (property "Mouser link" "https://www.mouser.com/ProductDetail/Nichicon/ULR2E100MNL1GS?qs=aoAypCcaRa8pBYU9738QBQ%3D%3D" (at 198.12 52.07 0)
       (effects (font (size 1.27 1.27)) hide)
     )
