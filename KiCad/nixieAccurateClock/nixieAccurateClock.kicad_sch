File: KiCad/nixieAccurateClock/nixieAccurateClock.kicad_sch (KiCad schematic)
At the start: 2 parts, among them J2 Conn_02x20_Odd_Even, J3 Conn_02x20_Odd_Even

Commit message: Connect pico iCE to GPS module
Parts:
- added JP1: M10X2, Connector_PinSocket_2.54mm:PinSocket_2x10_P2.54mm_Vertical, symbol GPS_Pi_Hat_0_2-eagle-import:M10X2
- J2: footprint RP2040_minimal:PinHeader_2x20_P2.54mm_Vertical_Left -> Connector_PinSocket_2.54mm:PinSocket_2x20_P2.54mm_Vertical
- J3: footprint RP2040_minimal:PinHeader_2x20_P2.54mm_Vertical_Right -> Connector_PinSocket_2.54mm:PinSocket_2x20_P2.54mm_Vertical
Connections:
- net GND: now also JP1.14, JP1.6, JP1.9
- net ICE_6: now also JP1.12
- net PICO_PMOD_B2: now also JP1.8
- net PICO_PMOD_B3: now also JP1.10
- net VBUS renamed +5V
- net +5V: now also JP1.2, JP1.4
- new net VCC: JP1.1

Commit message: Switch to discrete GPS module
Switch from GPS daughter board to direct connection since it is so easy to implement, can save on cost, and is higher performance.

Get project library stood up.

Add proper mounting holes for pico ice and group components together.
Parts:
- removed JP1: M10X2, Connector_PinSocket_2.54mm:PinSocket_2x10_P2.54mm_Vertical, symbol GPS_Pi_Hat_0_2-eagle-import:M10X2
- added H1, H2, H3, H4: MountingHole_Pad, MountingHole:MountingHole_2.5mm_Pad_Via, symbol Mechanical:MountingHole_Pad
- added J3: Conn_Coaxial, 00_lib:SMA_Amphenol_132289_EdgeMount, symbol Connector:Conn_Coaxial
- added U1: PX1125T, 00_lib:PX1125T, symbol 00_lib:PX1125T
Connections:
- net GND: now also H1.1, H2.1, H3.1, H4.1, J3.2 (Ext), U1.10 (GND), U1.12 (GND), U1.13 (GND), U1.24 (GND)
- net PICO_PMOD_B2: now also U1.21 (RXD)
- net PICO_PMOD_B3: now also U1.20 (TXD)
- new net: J3.1 (In), U1.11 (RF_IN)
Other:
- title: (none) -> Nixie Accurate Clock
