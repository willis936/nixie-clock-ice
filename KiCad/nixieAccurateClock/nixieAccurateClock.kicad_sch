File: KiCad/nixieAccurateClock/nixieAccurateClock.kicad_sch (KiCad schematic)
At the start: 16 parts, among them J2 Conn_02x20_Odd_Even, J3 Conn_02x20_Odd_Even, J3 Conn_Coaxial, Q1 PZTA42, U1 PX1125T

Commit message: Add DST controlling DIP switches
Parts:
- added R4, R5: 100k, Resistor_SMD:R_0603_1608Metric, symbol Device:R
- added SW1: SW_DIP_x02, Button_Switch_THT:SW_DIP_SPSTx02_Slide_6.7x6.64mm_W7.62mm_P2.54mm_LowProfile, symbol Switch:SW_DIP_x02
Connections:
- net +3V3: now also R4.2, R5.1
- net GND: now also SW1.3, SW1.4
- net ICE_28: now also R5.2, SW1.1
- net ICE_32: now also R4.1, SW1.2
Changed lines of the file:
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@@
   (junction (at 220.98 97.79) (diameter 0) (color 0 0 0 0)
   )
+  (junction (at 224.79 39.37) (diameter 0) (color 0 0 0 0)
+  )
   (junction (at 75.565 62.23) (diameter 0) (color 0 0 0 0)
   )
@@
   (junction (at 144.145 80.01) (diameter 0) (color 0 0 0 0)
   )
+  (junction (at 246.38 39.37) (diameter 0) (color 0 0 0 0)
+  )
   (junction (at 259.08 110.49) (diameter 0) (color 0 0 0 0)
   )
   (junction (at 144.145 69.85) (diameter 0) (color 0 0 0 0)
   )
+  (junction (at 224.79 36.83) (diameter 0) (color 0 0 0 0)
+  )
   (junction (at 75.565 77.47) (diameter 0) (color 0 0 0 0)
   )
@@
     (stroke (width 0) (type default))
   )
+  (wire (pts (xy 224.79 36.83) (xy 229.87 36.83))
+    (stroke (width 0) (type default))
+  )
   (wire (pts (xy 130.175 62.23) (xy 127 62.23))
     (stroke (width 0) (type default))
@@
     (stroke (width 0) (type default))
   )
+  (wire (pts (xy 222.25 36.83) (xy 224.79 36.83))
+    (stroke (width 0) (type default))
+  )
   (wire (pts (xy 92.71 172.72) (xy 109.22 172.72))
     (stroke (width 0) (type default))
@@
     (stroke (width 0) (type default))
   )
+  (wire (pts (xy 245.11 36.83) (xy 246.38 36.83))
+    (stroke (width 0) (type default))
+  )
   (polyline (pts (xy 38.735 57.15) (xy 38.735 73.025))
     (stroke (width 0) (type default))
@@
     (stroke (width 0) (type default))
   )
+  (wire (pts (xy 224.79 53.34) (xy 224.79 57.15))
+    (stroke (width 0) (type default))
+  )
   (polyline (pts (xy 165.735 35.56) (xy 161.29 35.56))
     (stroke (width 0) (type default))
   )
+  (wire (pts (xy 224.79 39.37) (xy 224.79 45.72))
+    (stroke (width 0) (type default))
+  )
   (polyline (pts (xy 161.925 74.295) (xy 165.735 74.295))
     (stroke (width 0) (type default))
   )
+  (wire (pts (xy 246.38 36.83) (xy 246.38 39.37))
+    (stroke (width 0) (type default))
+  )
   (wire (pts (xy 124.46 80.01) (xy 130.175 80.01))
     (stroke (width 0) (type default))
@@
     (stroke (width 0) (type default))
   )
+  (wire (pts (xy 245.11 39.37) (xy 246.38 39.37))
+    (stroke (width 0) (type default))
+  )
   (wire (pts (xy 54.61 31.75) (xy 60.96 31.75))
     (stroke (width 0) (type default))
@@
     (stroke (width 0) (type default))
   )
+  (wire (pts (xy 222.25 39.37) (xy 224.79 39.37))
+    (stroke (width 0) (type default))
+  )
+  (wire (pts (xy 246.38 39.37) (xy 246.38 41.91))
+    (stroke (width 0) (type default))
+  )
   (wire (pts (xy 73.66 69.85) (xy 78.74 69.85))
     (stroke (width 0) (type default))
@@
     (stroke (width 0) (type default))
   )
+  (wire (pts (xy 224.79 21.59) (xy 224.79 24.13))
+    (stroke (width 0) (type default))
+  )
   (wire (pts (xy 78.74 41.91) (xy 73.66 41.91))
     (stroke (width 0) (type default))
@@
     (stroke (width 0) (type default))
   )
+  (wire (pts (xy 229.87 39.37) (xy 224.79 39.37))
+    (stroke (width 0) (type default))
+  )
   (wire (pts (xy 129.54 69.85) (xy 129.54 46.99))
     (stroke (width 0) (type default))
@@
   )
   (wire (pts (xy 127 52.07) (xy 130.175 52.07))
+    (stroke (width 0) (type default))
+  )
+  (wire (pts (xy 224.79 31.75) (xy 224.79 36.83))
     (stroke (width 0) (type default))
   )
@@
     (effects (font (size 1.27 1.27)) (justify left top))
   )
+  (text_box "DIP switches to control DST behavior."
+    (at 236.22 46.99 0) (size 39.37 6.35)
+    (stroke (width 0) (type default))
+    (fill (type none))
+    (effects (font (size 1.27 1.27)) (justify left top))
+  )
   (text_box "GPS"
     (at 17.78 128.27 0) (size 125.73 64.77)
@@
     (effects (font (size 1.27 1.27)) (justify right bottom))
   )
+  (label "ICE_28" (at 222.25 36.83 180) (fields_autoplaced)
+    (effects (font (size 1.27 1.27)) (justify right bottom))
+  )
   (label "ICE_47" (at 78.74 67.31 0) (fields_autoplaced)
     (effects (font (size 1.27 1.27)) (justify left bottom))
@@
   )
   (label "ICE_44_G6" (at 54.61 64.77 180) (fields_autoplaced)
+    (effects (font (size 1.27 1.27)) (justify right bottom))
+  )
+  (label "ICE_32" (at 222.25 39.37 180) (fields_autoplaced)
     (effects (font (size 1.27 1.27)) (justify right bottom))
   )
@@
         (path "/55aab698-7558-4fe2-95ad-faa6da60ef89"
           (reference "H1") (unit 1)
+        )
+      )
+    )
+  )
+  (symbol (lib_id "power:+3V3") (at 224.79 21.59 0) (unit 1)
+    (in_bom yes) (on_board yes) (dnp no)
+    (property "Reference" "#PWR034" (at 224.79 25.4 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Value" "+3V3" (at 224.79 18.415 90)
+      (effects (font (size 1.27 1.27)) (justify left))
+    )
+    (property "Footprint" "" (at 224.79 21.59 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Datasheet" "" (at 224.79 21.59 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (pin "1")
+    (instances
+      (project "pico-ice"
+        (path "/2ff44921-0562-495a-89f5-ac439f192d90"
+          (reference "#PWR034") (unit 1)
+        )
+      )
+      (project "nixieAccurateClock"
+        (path "/55aab698-7558-4fe2-95ad-faa6da60ef89"
+          (reference "#PWR027") (unit 1)
         )
       )
@@
     )
   )
+  (symbol (lib_id "power:GND") (at 246.38 41.91 0) (mirror y) (unit 1)
+    (in_bom yes) (on_board yes) (dnp no)
+    (property "Reference" "#PWR059" (at 246.38 48.26 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Value" "GND" (at 250.19 43.18 0)
+      (effects (font (size 1.27 1.27)))
+    )
+    (property "Footprint" "" (at 246.38 41.91 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Datasheet" "" (at 246.38 41.91 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (pin "1")
+    (instances
+      (project "pico-ice"
+        (path "/2ff44921-0562-495a-89f5-ac439f192d90"
+          (reference "#PWR059") (unit 1)
+        )
+      )
+      (project "nixieAccurateClock"
+        (path "/55aab698-7558-4fe2-95ad-faa6da60ef89"
+          (reference "#PWR029") (unit 1)
+        )
+      )
+    )
+  )
   (symbol (lib_id "power:+3V3") (at 78.74 36.83 270) (unit 1)
     (in_bom yes) (on_board yes) (dnp no)
@@
     )
   )
+  (symbol (lib_id "Device:R") (at 224.79 49.53 0) (unit 1)
+    (in_bom yes) (on_board yes) (dnp no) (fields_autoplaced)
+    (property "Reference" "R4" (at 227.33 48.26 0)
+      (effects (font (size 1.27 1.27)) (justify left))
+    )
+    (property "Value" "100k" (at 227.33 50.8 0)
+      (effects (font (size 1.27 1.27)) (justify left))
+    )
+    (property "Footprint" "Resistor_SMD:R_0603_1608Metric" (at 223.012 49.53 90)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Datasheet" "~" (at 224.79 49.53 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (pin "1")
+    (pin "2")
+    (instances
+      (project "nixieAccurateClock"
+        (path "/55aab698-7558-4fe2-95ad-faa6da60ef89"
+          (reference "R4") (unit 1)
+        )
+      )
+    )
+  )
+  (symbol (lib_id "power:+3V3") (at 224.79 57.15 180) (unit 1)
+    (in_bom yes) (on_board yes) (dnp no)
+    (property "Reference" "#PWR034" (at 224.79 53.34 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Value" "+3V3" (at 224.79 60.325 90)
+      (effects (font (size 1.27 1.27)) (justify left))
+    )
+    (property "Footprint" "" (at 224.79 57.15 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Datasheet" "" (at 224.79 57.15 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (pin "1")
+    (instances
+      (project "pico-ice"
+        (path "/2ff44921-0562-495a-89f5-ac439f192d90"
+          (reference "#PWR034") (unit 1)
+        )
+      )
+      (project "nixieAccurateClock"
+        (path "/55aab698-7558-4fe2-95ad-faa6da60ef89"
+          (reference "#PWR028") (unit 1)
+        )
+      )
+    )
+  )
   (symbol (lib_name "GND_1") (lib_id "power:GND") (at 93.98 139.7 0) (mirror x) (unit 1)
     (in_bom yes) (on_board yes) (dnp no)
@@
     )
   )
+  (symbol (lib_id "Switch:SW_DIP_x02") (at 237.49 39.37 0) (unit 1)
+    (in_bom yes) (on_board yes) (dnp no) (fields_autoplaced)
+    (property "Reference" "SW1" (at 237.49 29.21 0)
+      (effects (font (size 1.27 1.27)))
+    )
+    (property "Value" "SW_DIP_x02" (at 237.49 31.75 0)
+      (effects (font (size 1.27 1.27)))
+    )
+    (property "Footprint" "Button_Switch_THT:SW_DIP_SPSTx02_Slide_6.7x6.64mm_W7.62mm_P2.54mm_LowProfile" (at 237.49 39.37 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Datasheet" "https://www.mouser.com/datasheet/2/670/ds02_254-1777565.pdf" (at 237.49 39.37 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Model" "DS02-254-1L-02BE" (at 237.49 39.37 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (pin "1")
+    (pin "4")
+    (pin "3")
+    (pin "2")
+    (instances
+      (project "nixieAccurateClock"
+        (path "/55aab698-7558-4fe2-95ad-faa6da60ef89"
+          (reference "SW1") (unit 1)
+        )
+      )
+    )
+  )
   (symbol (lib_id "power:+3V3") (at 148.59 72.39 270) (mirror x) (unit 1)
     (in_bom yes) (on_board yes) (dnp no)
@@
         )
       )
+    )
+  )
+  (symbol (lib_id "Device:R") (at 224.79 27.94 0) (unit 1)
+    (in_bom yes) (on_board yes) (dnp no) (fields_autoplaced)
+    (property "Reference" "R5" (at 227.33 26.67 0)
+      (effects (font (size 1.27 1.27)) (justify left))
+    )
+    (property "Value" "100k" (at 227.33 29.21 0)
+      (effects (font (size 1.27 1.27)) (justify left))
+    )
+    (property "Footprint" "Resistor_SMD:R_0603_1608Metric" (at 223.012 27.94 90)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Datasheet" "~" (at 224.79 27.94 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (pin "1")
+    (pin "2")
+    (instances
+      (project "nixieAccurateClock"
+        (path "/55aab698-7558-4fe2-95ad-faa6da60ef89"
+          (reference "R5") (unit 1)
+        )
+      )

Commit message: work on rules pass
Parts:
- removed C1: 47u, Capacitor_THT:C_Radial_D12.5mm_H20.0mm_P5.00mm, symbol Device:C_Polarized
- removed D1: SM4004, Diode_SMD:D_MELF, symbol Diode:SM4004
- removed L1: 680u, 00_lib:IND_MSS1583_COC, symbol Device:L
- removed Q1: PZTA42, Package_TO_SOT_SMD:SOT-223-3_TabPin2, symbol Transistor_BJT:PZTA42
- removed R1: 2k, Resistor_SMD:R_0603_1608Metric, symbol Device:R
- removed R2: 10M, Resistor_SMD:R_0603_1608Metric, symbol Device:R
- removed R3: 100k, Resistor_SMD:R_0603_1608Metric, symbol Device:R
Connections:
- net +5V: now also R4.2
- net +3V3 renamed +3.3V
- net +3.3V: no longer R4.2
Other:
- added sheet High voltage supply (hv_supply.kicad_sch)
- moved on the sheet: J3

Commit message: proper ERC and DRC pass
Parts:
- removed BT1: Battery_Cell, Battery:BatteryHolder_Keystone_103_1x20mm, symbol Device:Battery_Cell
- removed H1, H2, H3, H4: MountingHole_Pad, MountingHole:MountingHole_2.5mm_Pad_Via, symbol Mechanical:MountingHole_Pad
- removed J2, J3: Conn_02x20_Odd_Even, Connector_PinSocket_2.54mm:PinSocket_2x20_P2.54mm_Vertical, symbol Connector_Generic:Conn_02x20_Odd_Even
- removed J3: Conn_Coaxial, 00_lib:SMA_Amphenol_132289_EdgeMount, symbol Connector:Conn_Coaxial
- removed U1: PX1125T, 00_lib:PX1125T, symbol 00_lib:PX1125T
- added J1, J2, J3: Conn_01x02_Pin, Connector_PinHeader_2.54mm:PinHeader_1x02_P2.54mm_Vertical, symbol Connector:Conn_01x02_Pin
- added U1: ~, 00_lib:pico iCE, symbol 00_lib:pico_iCE
- renumbered R5 to R1, R4 to R2
Connections:
- net +3.3V: now also R2.2, U1.5 (+3.3V), U1.56 (+3.3V)
- net +3V3_STDBY: now also U1.77 (+3V3_STDBY)
- net +5V: now also U1.79 (+5V); no longer R2.2
- net GND: now also J1.2 (Pin_2), J2.2 (Pin_2), J3.2 (Pin_2), U1.25 (GND), U1.26 (GND), U1.38 (GND), U1.4 (GND), U1.53 (GND), U1.54 (GND), U1.7 (GND), U1.71 (GND), U1.72 (GND)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
- net ~{ICE_RST}: now also J3.1 (Pin_1), U1.2 (~{ICE_RST})
- net ~{RESET}: now also J1.1 (Pin_1), U1.36 (~{RESET})
- net ~{USB_BOOT}: now also J2.1 (Pin_1), U1.40 (~{USB_BOOT})
- net ICE_28 renamed DST_check
- net DST_check: now also U1.9 (ICE_28)
- net ICE_32 renamed DST_force
- net DST_force: now also U1.11 (ICE_32)
- new net GPS_1PPS: U1.52 (ICE_20_G3)
- new net GPS_1PPS2: U1.48 (ICE_18)
- new net GPS_BOOT_SEL: U1.63 (PICO_PMOD_A1)
- new net GPS_RSTN: U1.69 (PICO_PMOD_A4)
- new net GPS_RXD: U1.66 (PICO_PMOD_B2)
- new net GPS_TXD: U1.68 (PICO_PMOD_B3)
- new net HV_GATE: U1.64 (PICO_PMOD_B1)
- new net HV_SENSE: U1.61 (ADC3)
Other:
- added sheet GPS (gps.kicad_sch)
- note removed: "Debug"
- note removed: "LED/ADC"
- note removed: "PICO-iCE Headers"
- note removed: "Pico PMOD"
- note removed: "Power"
- note removed: "Rx"
- note removed: "SCK"
- note removed: "SSn"
- note removed: "Tx"
- note removed: "USBC"
- note removed: "iCE Flash"
- note removed: "iCE Misc"
- note removed: "iCE PMOD"
- note removed: "iCE Prog"
