File: KiCad/nixieAccurateClock/nixieAccurateClock.kicad_sch (KiCad schematic)
At the start: 8 parts, among them J2 Conn_02x20_Odd_Even, J3 Conn_02x20_Odd_Even, J3 Conn_Coaxial, U1 PX1125T

Commit message: finish GPS module power and I/O
Parts:
- added BT1: Battery_Cell, Battery:BatteryHolder_Keystone_103_1x20mm, symbol Device:Battery_Cell
Connections:
- net +3V3: now also U1.23 (VCC)
- net +3V3_STDBY: now also U1.22 (V_BCKP), BT1.1 (+)
- net GND: now also BT1.2 (-)
- net PICO_PMOD_A1: now also U1.1 (BOOT_SEL)
- net PICO_PMOD_A2: now also U1.3 (1PPS)
- net PICO_PMOD_A3: now also U1.4 (1PPS2)
- net PICO_PMOD_A4: now also U1.8 (RSTN)
Other:
- moved on the sheet: J3
Changed lines of the file:
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@@
     (stroke (width 0) (type default))
   )
-  (wire (pts (xy 182.88 138.43) (xy 182.88 142.24))
+  (wire (pts (xy 194.31 138.43) (xy 194.31 142.24))
     (stroke (width 0) (type default))
   )
@@
     (stroke (width 0) (type default))
   )
+  (wire (pts (xy 165.1 158.75) (xy 181.61 158.75))
+    (stroke (width 0) (type default))
+  )
   (wire (pts (xy 116.84 158.75) (xy 119.38 158.75))
     (stroke (width 0) (type default))
@@
     (stroke (width 0) (type default))
   )
+  (wire (pts (xy 115.57 156.21) (xy 119.38 156.21))
+    (stroke (width 0) (type default))
+  )
   (wire (pts (xy 73.66 72.39) (xy 78.74 72.39))
     (stroke (width 0) (type default))
@@
     (stroke (width 0) (type default))
   )
+  (wire (pts (xy 165.1 153.67) (xy 181.61 153.67))
+    (stroke (width 0) (type default))
+  )
   (wire (pts (xy 73.66 46.99) (xy 78.74 46.99))
     (stroke (width 0) (type default))
   )
-  (wire (pts (xy 165.1 133.35) (xy 177.8 133.35))
+  (wire (pts (xy 165.1 133.35) (xy 189.23 133.35))
     (stroke (width 0) (type default))
   )
@@
     (stroke (width 0) (type default))
   )
+  (wire (pts (xy 100.33 153.67) (xy 119.38 153.67))
+    (stroke (width 0) (type default))
+  )
   (wire (pts (xy 54.61 74.93) (xy 60.96 74.93))
     (stroke (width 0) (type default))
@@
     (stroke (width 0) (type default))
   )
+  (wire (pts (xy 100.33 163.83) (xy 100.33 168.91))
+    (stroke (width 0) (type default))
+  )
   (wire (pts (xy 143.51 96.52) (xy 146.05 96.52))
     (stroke (width 0) (type default))
@@
     (stroke (width 0) (type default))
   )
+  (wire (pts (xy 100.33 153.67) (xy 100.33 156.21))
+    (stroke (width 0) (type default))
+  )
   (polyline (pts (xy 38.735 80.01) (xy 42.545 80.01))
     (stroke (width 0) (type default))
@@
     (stroke (width 0) (type default))
   )
+  (wire (pts (xy 165.1 151.13) (xy 181.61 151.13))
+    (stroke (width 0) (type default))
+  )
   (wire (pts (xy 78.74 41.91) (xy 73.66 41.91))
     (stroke (width 0) (type default))
@@
   )
   (polyline (pts (xy 38.735 77.47) (xy 38.735 80.01))
+    (stroke (width 0) (type default))
+  )
+  (wire (pts (xy 165.1 140.97) (xy 181.61 140.97))
     (stroke (width 0) (type default))
   )
@@
     (effects (font (size 1.27 1.27)) (justify left bottom))
   )
+  (label "+3V3_STDBY" (at 116.84 153.67 180) (fields_autoplaced)
+    (effects (font (size 1.27 1.27)) (justify right bottom))
+  )
   (label "ADC2|PB" (at 127 54.61 180) (fields_autoplaced)
     (effects (font (size 1.27 1.27)) (justify right bottom))
@@
     (effects (font (size 1.27 1.27)) (justify right bottom))
   )
+  (label "PICO_PMOD_A2" (at 181.61 153.67 180) (fields_autoplaced)
+    (effects (font (size 1.27 1.27)) (justify right bottom))
+  )
   (label "SRAM_SS" (at 54.61 52.07 180) (fields_autoplaced)
     (effects (font (size 1.27 1.27)) (justify right bottom))
@@
     (effects (font (size 1.27 1.27)) (justify right bottom))
   )
+  (label "PICO_PMOD_A3" (at 181.61 151.13 180) (fields_autoplaced)
+    (effects (font (size 1.27 1.27)) (justify right bottom))
+  )
   (label "~{ICE_RST}" (at 78.74 31.75 0) (fields_autoplaced)
     (effects (font (size 1.27 1.27)) (justify left bottom))
@@
     (effects (font (size 1.27 1.27)) (justify left bottom))
   )
+  (label "PICO_PMOD_A1" (at 181.61 158.75 180) (fields_autoplaced)
+    (effects (font (size 1.27 1.27)) (justify right bottom))
+  )
   (label "ICE_DONE_ADC0" (at 127 52.07 180) (fields_autoplaced)
     (effects (font (size 1.27 1.27)) (justify right bottom))
@@
   (label "PWR_EN" (at 146.685 77.47 0) (fields_autoplaced)
     (effects (font (size 1.27 1.27)) (justify left bottom))
+  )
+  (label "PICO_PMOD_A4" (at 181.61 140.97 180) (fields_autoplaced)
+    (effects (font (size 1.27 1.27)) (justify right bottom))
   )
   (symbol (lib_name "GND_1") (lib_id "power:GND") (at 116.84 125.73 180) (unit 1)
@@
     )
   )
+  (symbol (lib_name "GND_1") (lib_id "power:GND") (at 100.33 168.91 0) (mirror y) (unit 1)
+    (in_bom yes) (on_board yes) (dnp no)
+    (property "Reference" "#PWR021" (at 100.33 175.26 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Value" "GND" (at 100.33 173.99 0)
+      (effects (font (size 1.27 1.27)))
+    )
+    (property "Footprint" "" (at 100.33 168.91 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Datasheet" "" (at 100.33 168.91 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (pin "1")
+    (instances
+      (project "nixieAccurateClock"
+        (path "/55aab698-7558-4fe2-95ad-faa6da60ef89"
+          (reference "#PWR021") (unit 1)
+        )
+      )
+    )
+  )
   (symbol (lib_name "GND_1") (lib_id "power:GND") (at 166.37 125.73 0) (mirror x) (unit 1)
     (in_bom yes) (on_board yes) (dnp no)
@@
     )
   )
-  (symbol (lib_name "GND_1") (lib_id "power:GND") (at 182.88 142.24 0) (mirror y) (unit 1)
-    (in_bom yes) (on_board yes) (dnp no)
-    (property "Reference" "#PWR020" (at 182.88 148.59 0)
-      (effects (font (size 1.27 1.27)) hide)
-    )
-    (property "Value" "GND" (at 182.88 147.32 0)
-      (effects (font (size 1.27 1.27)))
-    )
-    (property "Footprint" "" (at 182.88 142.24 0)
-      (effects (font (size 1.27 1.27)) hide)
-    )
-    (property "Datasheet" "" (at 182.88 142.24 0)
+  (symbol (lib_name "GND_1") (lib_id "power:GND") (at 194.31 142.24 0) (mirror y) (unit 1)
+    (in_bom yes) (on_board yes) (dnp no)
+    (property "Reference" "#PWR020" (at 194.31 148.59 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Value" "GND" (at 194.31 147.32 0)
+      (effects (font (size 1.27 1.27)))
+    )
+    (property "Footprint" "" (at 194.31 142.24 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Datasheet" "" (at 194.31 142.24 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
     )
   )
-  (symbol (lib_id "Connector:Conn_Coaxial") (at 182.88 133.35 0) (unit 1)
+  (symbol (lib_id "Connector:Conn_Coaxial") (at 194.31 133.35 0) (unit 1)
     (in_bom yes) (on_board yes) (dnp no) (fields_autoplaced)
-    (property "Reference" "J3" (at 186.69 132.3732 0)
+    (property "Reference" "J3" (at 198.12 132.3732 0)
       (effects (font (size 1.27 1.27)) (justify left))
     )
-    (property "Value" "Conn_Coaxial" (at 186.69 134.9132 0)
+    (property "Value" "Conn_Coaxial" (at 198.12 134.9132 0)
       (effects (font (size 1.27 1.27)) (justify left))
     )
-    (property "Footprint" "00_lib:SMA_Amphenol_132289_EdgeMount" (at 182.88 133.35 0)
-      (effects (font (size 1.27 1.27)) hide)
-    )
-    (property "Datasheet" "https://s3-us-west-2.amazonaws.com/catsy.582/132289.pdf" (at 182.88 133.35 0)
+    (property "Footprint" "00_lib:SMA_Amphenol_132289_EdgeMount" (at 194.31 133.35 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Datasheet" "https://s3-us-west-2.amazonaws.com/catsy.582/132289.pdf" (at 194.31 133.35 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
     )
   )
+  (symbol (lib_id "Device:Battery_Cell") (at 100.33 161.29 0) (unit 1)
+    (in_bom yes) (on_board yes) (dnp no) (fields_autoplaced)
+    (property "Reference" "BT1" (at 104.14 158.1785 0)
+      (effects (font (size 1.27 1.27)) (justify left))
+    )
+    (property "Value" "Battery_Cell" (at 104.14 160.7185 0)
+      (effects (font (size 1.27 1.27)) (justify left))
+    )
+    (property "Footprint" "Battery:BatteryHolder_Keystone_103_1x20mm" (at 100.33 159.766 90)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Datasheet" "https://www.keyelco.com/userAssets/file/M65p3.pdf" (at 100.33 159.766 90)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (pin "1")
+    (pin "2")
+    (instances
+      (project "nixieAccurateClock"
+        (path "/55aab698-7558-4fe2-95ad-faa6da60ef89"
+          (reference "BT1") (unit 1)
+        )
+      )
+    )
+  )
   (symbol (lib_id "power:+3V3") (at 147.955 72.39 270) (mirror x) (unit 1)
     (in_bom yes) (on_board yes) (dnp no)
@@
         )
       )
+    )
+  )
+  (symbol (lib_id "power:+3V3") (at 115.57 156.21 90) (unit 1)
+    (in_bom yes) (on_board yes) (dnp no)
+    (property "Reference" "#PWR032" (at 119.38 156.21 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Value" "+3V3" (at 112.395 155.575 90)
+      (effects (font (size 1.27 1.27)) (justify left))
+    )
+    (property "Footprint" "" (at 115.57 156.21 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Datasheet" "" (at 115.57 156.21 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (pin "1")
+    (instances
+      (project "pico-ice"
+        (path "/2ff44921-0562-495a-89f5-ac439f192d90"
+          (reference "#PWR032") (unit 1)
+        )
+      )
+      (project "nixieAccurateClock"
+        (path "/55aab698-7558-4fe2-95ad-faa6da60ef89"
+          (reference "#PWR022") (unit 1)
+        )
+      )

Commit message: Add high voltage supply
Parts:
- added C1: 47u, Capacitor_THT:C_Radial_D12.5mm_H20.0mm_P5.00mm, symbol Device:C_Polarized
- added D1: SM4004, Diode_SMD:D_MELF, symbol Diode:SM4004
- added L1: 680u, 00_lib:IND_MSS1583_COC, symbol Device:L
- added Q1: PZTA42, Package_TO_SOT_SMD:SOT-223-3_TabPin2, symbol Transistor_BJT:PZTA42
- added R1: 2k, Resistor_SMD:R_0603_1608Metric, symbol Device:R
- added R2: 10M, Resistor_SMD:R_0603_1608Metric, symbol Device:R
- added R3: 100k, Resistor_SMD:R_0603_1608Metric, symbol Device:R
Connections:
- net +5V: now also L1.1
- net ADC3: now also R2.2, R3.1
- net GND: now also C1.2, Q1.3 (E), R3.2
- net PICO_PMOD_B1: now also R1.1
- new net: D1.2 (A), L1.2, Q1.2 (C)
- new net: C1.1, D1.1 (K), R2.1
- new net: Q1.1 (B), R1.2
Other:
- moved on the sheet: BT1, J3, U1
