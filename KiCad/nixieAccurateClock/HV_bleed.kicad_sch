File: KiCad/nixieAccurateClock/HV_bleed.kicad_sch (KiCad schematic)
At the start: 8 parts, among them Q3 BSP88, Q4 BSP88

Commit message: finish schematic features
Parts:
- added TP16, TP17, TP18, TP19: TestPoint, TestPoint:TestPoint_Loop_D2.54mm_Drill1.5mm_Beaded, symbol Connector:TestPoint
- renumbered C12 to C13, Q4 to Q3, Q3 to Q4, R23 to R22, R24 to R23, R22 to R24
Connections:
- net GND: now also TP19.1
- net HV_Bleed_{drain} renamed HV_bleed_{drain}
- net HV_bleed_{drain}: now also TP16.1
- net HV_Bleed_{gate} renamed HV_bleed_{gate}
- net HV_bleed_{gate}: now also TP17.1
- net HV_Bleed_{pulldown} renamed HV_bleed_{pulldown}
- net HV_Bleed_{source} renamed HV_bleed_{source}
- net HV_bleed_{source}: now also TP18.1
Other:
- company: (none) -> Paul Willis
- title: (none) -> Nixie Accurate Clock

Commit message: ERC pass
Close look at pico iCE pinout
Add light sensor
Rough layout for non-HV
Parts:
- renumbered C13 to C15, R22 to R24, R23 to R25, R24 to R26, R25 to R27
Changed lines of the file:
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@@
   (symbol (lib_id "Device:R") (at 106.68 85.09 0) (unit 1)
     (in_bom yes) (on_board yes) (dnp no) (fields_autoplaced)
-    (property "Reference" "R25" (at 109.22 83.82 0)
+    (property "Reference" "R27" (at 109.22 83.82 0)
       (effects (font (size 1.27 1.27)) (justify left))
     )
@@
       (project "nixieAccurateClock"
         (path "/55aab698-7558-4fe2-95ad-faa6da60ef89/21095f53-01f6-40ea-bb6b-e8b09c532104"
+          (reference "R27") (unit 1)
+        )
+      )
+    )
+  )
+  (symbol (lib_id "Connector:TestPoint") (at 66.04 68.58 90) (unit 1)
+    (in_bom yes) (on_board yes) (dnp no) (fields_autoplaced)
+    (property "Reference" "TP17" (at 62.738 63.5 90)
+      (effects (font (size 1.27 1.27)))
+    )
+    (property "Value" "TestPoint" (at 62.738 66.04 90)
+      (effects (font (size 1.27 1.27)))
+    )
+    (property "Footprint" "TestPoint:TestPoint_Loop_D2.54mm_Drill1.5mm_Beaded" (at 66.04 63.5 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Datasheet" "https://www.keyelco.com/userAssets/file/M65p56.pdf" (at 66.04 63.5 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Model" "5001" (at 66.04 68.58 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Sim.Enable" "0" (at 66.04 68.58 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (pin "1")
+    (instances
+      (project "nixieAccurateClock"
+        (path "/55aab698-7558-4fe2-95ad-faa6da60ef89/21095f53-01f6-40ea-bb6b-e8b09c532104"
+          (reference "TP17") (unit 1)
+        )
+      )
+    )
+  )
+  (symbol (lib_id "Device:R") (at 95.25 50.8 0) (unit 1)
+    (in_bom yes) (on_board yes) (dnp no) (fields_autoplaced)
+    (property "Reference" "R25" (at 97.79 49.53 0)
+      (effects (font (size 1.27 1.27)) (justify left))
+    )
+    (property "Value" "10k" (at 97.79 52.07 0)
+      (effects (font (size 1.27 1.27)) (justify left))
+    )
+    (property "Footprint" "Resistor_THT:R_Axial_DIN0617_L17.0mm_D6.0mm_P20.32mm_Horizontal" (at 93.472 50.8 90)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Datasheet" "https://www.te.com/usa-en/product-8-2176412-0.datasheet.pdf" (at 95.25 50.8 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Sim.Enable" "0" (at 95.25 50.8 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Model" "ROX5SSJ10K" (at 95.25 50.8 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (pin "1")
+    (pin "2")
+    (instances
+      (project "nixieAccurateClock"
+        (path "/55aab698-7558-4fe2-95ad-faa6da60ef89/21095f53-01f6-40ea-bb6b-e8b09c532104"
           (reference "R25") (unit 1)
         )
@@
     )
   )
-  (symbol (lib_id "Connector:TestPoint") (at 66.04 68.58 90) (unit 1)
-    (in_bom yes) (on_board yes) (dnp no) (fields_autoplaced)
-    (property "Reference" "TP17" (at 62.738 63.5 90)
-      (effects (font (size 1.27 1.27)))
-    )
-    (property "Value" "TestPoint" (at 62.738 66.04 90)
-      (effects (font (size 1.27 1.27)))
-    )
-    (property "Footprint" "TestPoint:TestPoint_Loop_D2.54mm_Drill1.5mm_Beaded" (at 66.04 63.5 0)
-      (effects (font (size 1.27 1.27)) hide)
-    )
-    (property "Datasheet" "https://www.keyelco.com/userAssets/file/M65p56.pdf" (at 66.04 63.5 0)
-      (effects (font (size 1.27 1.27)) hide)
-    )
-    (property "Model" "5001" (at 66.04 68.58 0)
-      (effects (font (size 1.27 1.27)) hide)
-    )
-    (property "Sim.Enable" "0" (at 66.04 68.58 0)
-      (effects (font (size 1.27 1.27)) hide)
-    )
-    (pin "1")
-    (instances
-      (project "nixieAccurateClock"
-        (path "/55aab698-7558-4fe2-95ad-faa6da60ef89/21095f53-01f6-40ea-bb6b-e8b09c532104"
-          (reference "TP17") (unit 1)
-        )
-      )
-    )
-  )
-  (symbol (lib_id "Device:R") (at 95.25 50.8 0) (unit 1)
-    (in_bom yes) (on_board yes) (dnp no) (fields_autoplaced)
-    (property "Reference" "R23" (at 97.79 49.53 0)
-      (effects (font (size 1.27 1.27)) (justify left))
-    )
-    (property "Value" "10k" (at 97.79 52.07 0)
-      (effects (font (size 1.27 1.27)) (justify left))
-    )
-    (property "Footprint" "Resistor_THT:R_Axial_DIN0617_L17.0mm_D6.0mm_P20.32mm_Horizontal" (at 93.472 50.8 90)
-      (effects (font (size 1.27 1.27)) hide)
-    )
-    (property "Datasheet" "https://www.te.com/usa-en/product-8-2176412-0.datasheet.pdf" (at 95.25 50.8 0)
-      (effects (font (size 1.27 1.27)) hide)
-    )
-    (property "Sim.Enable" "0" (at 95.25 50.8 0)
-      (effects (font (size 1.27 1.27)) hide)
-    )
-    (property "Model" "ROX5SSJ10K" (at 95.25 50.8 0)
-      (effects (font (size 1.27 1.27)) hide)
-    )
-    (pin "1")
-    (pin "2")
-    (instances
-      (project "nixieAccurateClock"
-        (path "/55aab698-7558-4fe2-95ad-faa6da60ef89/21095f53-01f6-40ea-bb6b-e8b09c532104"
-          (reference "R23") (unit 1)
-        )
-      )
-    )
-  )
   (symbol (lib_id "power:GND") (at 121.92 92.71 0) (unit 1)
     (in_bom yes) (on_board yes) (dnp no) (fields_autoplaced)
-    (property "Reference" "#PWR049" (at 121.92 99.06 0)
+    (property "Reference" "#PWR057" (at 121.92 99.06 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
       (project "nixieAccurateClock"
         (path "/55aab698-7558-4fe2-95ad-faa6da60ef89/21095f53-01f6-40ea-bb6b-e8b09c532104"
-          (reference "#PWR049") (unit 1)
+          (reference "#PWR057") (unit 1)
         )
       )
@@
   (symbol (lib_id "Device:R") (at 53.34 85.09 180) (unit 1)
     (in_bom yes) (on_board yes) (dnp no) (fields_autoplaced)
-    (property "Reference" "R24" (at 55.88 83.82 0)
+    (property "Reference" "R26" (at 55.88 83.82 0)
       (effects (font (size 1.27 1.27)) (justify right))
     )
@@
       (project "nixieAccurateClock"
         (path "/55aab698-7558-4fe2-95ad-faa6da60ef89/21095f53-01f6-40ea-bb6b-e8b09c532104"
-          (reference "R24") (unit 1)
+          (reference "R26") (unit 1)
         )
       )
@@
   (symbol (lib_id "Device:C") (at 95.25 85.09 0) (unit 1)
     (in_bom yes) (on_board yes) (dnp no) (fields_autoplaced)
-    (property "Reference" "C13" (at 99.06 83.82 0)
+    (property "Reference" "C15" (at 99.06 83.82 0)
       (effects (font (size 1.27 1.27)) (justify left))
     )
@@
       (project "nixieAccurateClock"
         (path "/55aab698-7558-4fe2-95ad-faa6da60ef89/21095f53-01f6-40ea-bb6b-e8b09c532104"
-          (reference "C13") (unit 1)
+          (reference "C15") (unit 1)
         )
       )
@@
   (symbol (lib_id "power:GND") (at 53.34 93.98 0) (unit 1)
     (in_bom yes) (on_board yes) (dnp no) (fields_autoplaced)
-    (property "Reference" "#PWR050" (at 53.34 100.33 0)
+    (property "Reference" "#PWR058" (at 53.34 100.33 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
       (project "nixieAccurateClock"
         (path "/55aab698-7558-4fe2-95ad-faa6da60ef89/21095f53-01f6-40ea-bb6b-e8b09c532104"
-          (reference "#PWR050") (unit 1)
+          (reference "#PWR058") (unit 1)
         )
       )
@@
   (symbol (lib_id "Device:R") (at 69.85 50.8 180) (unit 1)
     (in_bom yes) (on_board yes) (dnp no) (fields_autoplaced)
-    (property "Reference" "R22" (at 72.39 49.53 0)
+    (property "Reference" "R24" (at 72.39 49.53 0)
       (effects (font (size 1.27 1.27)) (justify right))
     )
@@
       (project "nixieAccurateClock"
         (path "/55aab698-7558-4fe2-95ad-faa6da60ef89/21095f53-01f6-40ea-bb6b-e8b09c532104"
-          (reference "R22") (unit 1)
+          (reference "R24") (unit 1)
         )
       )
@@
   (symbol (lib_id "power:VPP") (at 69.85 41.91 0) (unit 1)
     (in_bom yes) (on_board yes) (dnp no) (fields_autoplaced)
-    (property "Reference" "#PWR047" (at 69.85 45.72 0)
+    (property "Reference" "#PWR055" (at 69.85 45.72 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
       (project "nixieAccurateClock"
         (path "/55aab698-7558-4fe2-95ad-faa6da60ef89/21095f53-01f6-40ea-bb6b-e8b09c532104"
-          (reference "#PWR047") (unit 1)
+          (reference "#PWR055") (unit 1)
         )
       )
@@
   (symbol (lib_id "power:+5V") (at 53.34 73.66 0) (unit 1)
     (in_bom yes) (on_board yes) (dnp no) (fields_autoplaced)
-    (property "Reference" "#PWR048" (at 53.34 77.47 0)
+    (property "Reference" "#PWR056" (at 53.34 77.47 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
       (project "nixieAccurateClock"
         (path "/55aab698-7558-4fe2-95ad-faa6da60ef89/21095f53-01f6-40ea-bb6b-e8b09c532104"
-          (reference "#PWR048") (unit 1)
-        )
-      )
+          (reference "#PWR056") (unit 1)
+        )
+      )

Commit message: DRC pass
it's messy
Parts:
- removed R26: 4.7k, Resistor_SMD:R_0603_1608Metric, symbol Device:R
- removed TP19: TestPoint, TestPoint:TestPoint_Loop_D2.54mm_Drill1.5mm_Beaded, symbol Connector:TestPoint
- renumbered R27 to R26, TP16 to TP14, TP17 to TP15, TP18 to TP16
Connections:
- net VPP renamed HV_{SENSE}

Commit message: Fill out BOM
Parts:
- C15: Price (none) -> 0.10
- D3: Model (none) -> SM4004; Price (none) -> 0.27
- Q3, Q4: Model (none) -> BSP88; Price (none) -> 0.60
- R24: Model (none) -> RMCF0603FT1M00; Price (none) -> 0.10
- R25: Price (none) -> 0.60
- R26: Model (none) -> RC0603JR-07100KL; Price (none) -> 0.10
- TP14: Price (none) -> 0.38; now fitted
- TP15, TP16: Price (none) -> 0.38
Changed lines of the file:
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@@
       (effects (font (size 1.27 1.27)) (justify left) hide)
     )
+    (property "Model" "BSP88" (at 92.71 68.58 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Price" "0.60" (at 92.71 68.58 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
     (pin "1")
     (pin "3")
@@
       (effects (font (size 1.27 1.27)) hide)
     )
-    (property "Datasheet" "~" (at 106.68 85.09 0)
-      (effects (font (size 1.27 1.27)) hide)
-    )
-    (property "Sim.Enable" "0" (at 106.68 85.09 0)
+    (property "Datasheet" "https://www.yageo.com/upload/media/product/app/datasheet/rchip/pyu-rc_group_51_rohs_l.pdf" (at 106.68 85.09 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Sim.Enable" "" (at 106.68 85.09 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Model" "RC0603JR-07100KL" (at 106.68 85.09 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Price" "0.10" (at 106.68 85.09 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
       (effects (font (size 1.27 1.27)) hide)
     )
+    (property "Price" "0.38" (at 66.04 68.58 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
     (pin "1")
     (instances
@@
     )
     (property "Model" "ROX5SSJ10K" (at 95.25 50.8 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Price" "0.60" (at 95.25 50.8 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
       (effects (font (size 1.27 1.27)) (justify left) hide)
     )
+    (property "Model" "BSP88" (at 67.31 77.47 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Price" "0.60" (at 67.31 77.47 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
     (pin "1")
     (pin "3")
@@
       (effects (font (size 1.27 1.27)) hide)
     )
+    (property "Price" "0.10" (at 95.25 85.09 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
     (pin "2")
     (pin "1")
@@
   (symbol (lib_id "power:GND") (at 69.85 93.98 0) (unit 1)
     (in_bom yes) (on_board yes) (dnp no) (fields_autoplaced)
-    (property "Reference" "#PWR055" (at 69.85 100.33 0)
+    (property "Reference" "#PWR054" (at 69.85 100.33 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
       (project "nixieAccurateClock"
         (path "/55aab698-7558-4fe2-95ad-faa6da60ef89/21095f53-01f6-40ea-bb6b-e8b09c532104"
-          (reference "#PWR055") (unit 1)
+          (reference "#PWR054") (unit 1)
         )
       )
@@
       (effects (font (size 1.27 1.27)) hide)
     )
+    (property "Price" "0.38" (at 90.17 77.47 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
     (pin "1")
     (instances
@@
       (effects (font (size 1.27 1.27)) hide)
     )
-    (property "Datasheet" "~" (at 69.85 50.8 0)
+    (property "Datasheet" "https://www.seielect.com/catalog/sei-rmcf_rmcp.pdf" (at 69.85 50.8 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Model" "RMCF0603FT1M00" (at 69.85 50.8 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Price" "0.10" (at 69.85 50.8 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
       (effects (font (size 1.27 1.27)) hide)
     )
+    (property "Model" "SM4004" (at 69.85 60.96 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Price" "0.27" (at 69.85 60.96 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
     (pin "1")
     (pin "2")
@@
   )
   (symbol (lib_id "Connector:TestPoint") (at 90.17 58.42 90) (mirror x) (unit 1)
-    (in_bom yes) (on_board yes) (dnp yes)
+    (in_bom yes) (on_board yes) (dnp no)
     (property "Reference" "TP14" (at 86.868 63.5 90)
       (effects (font (size 1.27 1.27)))
@@
       (effects (font (size 1.27 1.27)) hide)
     )
+    (property "Price" "0.38" (at 90.17 58.42 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
     (pin "1")
     (instances
@@
   (symbol (lib_id "power:+5V") (at 59.69 77.47 90) (unit 1)
     (in_bom yes) (on_board yes) (dnp no) (fields_autoplaced)
-    (property "Reference" "#PWR054" (at 63.5 77.47 0)
+    (property "Reference" "#PWR053" (at 63.5 77.47 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
       (project "nixieAccurateClock"
         (path "/55aab698-7558-4fe2-95ad-faa6da60ef89/21095f53-01f6-40ea-bb6b-e8b09c532104"
-          (reference "#PWR054") (unit 1)
-        )
-      )
+          (reference "#PWR053") (unit 1)
+        )
+      )
